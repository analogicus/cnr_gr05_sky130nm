v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_fd_pr/cap_mim_m3_2.sym} 140 340 0 0 {name=C3 model=cap_mim_m3_2 W=2 L=2 MF=1 spiceprefix=X}
