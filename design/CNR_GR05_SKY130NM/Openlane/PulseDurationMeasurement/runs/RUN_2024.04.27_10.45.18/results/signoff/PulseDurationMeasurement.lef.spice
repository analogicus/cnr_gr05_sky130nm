* NGSPICE file created from PulseDurationMeasurement.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_8 abstract view
.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_4 abstract view
.subckt sky130_fd_sc_hd__a311o_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_4 abstract view
.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_4 abstract view
.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

.subckt PulseDurationMeasurement EN RS RW VGND VPWR clk data_in[0] data_in[1] data_in[2]
+ data_in[3] data_in[4] data_in[5] data_in[6] data_in[7] data_out[0] data_out[1] data_out[2]
+ data_out[3] data_out[4] data_out[5] data_out[6] data_out[7] reset_n signal_in
X_2037_ clknet_leaf_24_clk _0009_ VGND VGND VPWR VPWR temperature_output\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1270_ _0321_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1606_ data_reg\[8\]\[1\] data_reg\[9\]\[1\] data_reg\[10\]\[1\] data_reg\[11\]\[1\]
+ _0494_ _0495_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__mux4_1
X_0985_ _0732_ net212 _0728_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__mux2_1
X_1399_ net5 net258 _0389_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__mux2_1
X_1537_ count\[1\] count\[0\] _0671_ _0464_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__o211a_1
X_1468_ net156 net116 _0745_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold181 data_reg\[5\]\[3\] VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dlygate4sd3_1
Xhold192 pulse_duration\[1\] VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dlygate4sd3_1
Xhold170 data_reg\[14\]\[6\] VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1253_ net11 VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__buf_2
X_1322_ _0886_ net177 _0342_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_19_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1184_ _0848_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0968_ _0717_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__buf_4
XFILLER_0_6_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0899_ _0676_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_2_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1940_ clknet_leaf_13_clk _0180_ VGND VGND VPWR VPWR data_reg\[24\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_1871_ clknet_leaf_4_clk _0111_ VGND VGND VPWR VPWR data_reg\[6\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_51_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1305_ _0886_ net229 _0333_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__mux2_1
X_1236_ _0878_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__clkbuf_1
X_1098_ _0798_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__clkbuf_1
X_1167_ _0839_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_8_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2070_ clknet_leaf_10_clk _0294_ VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1021_ _0755_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1854_ clknet_leaf_3_clk _0094_ VGND VGND VPWR VPWR data_reg\[12\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_1923_ clknet_leaf_19_clk _0163_ VGND VGND VPWR VPWR data_reg\[21\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_1785_ clknet_leaf_1_clk _0033_ VGND VGND VPWR VPWR data_reg\[15\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1219_ _0867_ net277 _0865_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_35_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold74 data_reg\[8\]\[2\] VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dlygate4sd3_1
Xhold41 _0750_ VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 temperature_output\[13\] VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 data_reg\[3\]\[6\] VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 count\[9\] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_58_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold96 data_reg\[6\]\[0\] VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dlygate4sd3_1
Xhold85 temperature_output\[2\] VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_41_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1570_ net299 VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__inv_2
XFILLER_0_21_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2053_ clknet_leaf_0_clk _0277_ VGND VGND VPWR VPWR count\[1\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_20_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1004_ _0745_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__buf_4
X_1768_ net8 net228 _0661_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1837_ clknet_leaf_10_clk _0077_ VGND VGND VPWR VPWR data_reg\[9\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_1906_ clknet_leaf_20_clk _0146_ VGND VGND VPWR VPWR data_reg\[11\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_1699_ net23 _0608_ _0609_ _0507_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__a22o_1
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput20 net20 VGND VGND VPWR VPWR data_out[6] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1622_ data_reg\[28\]\[2\] _0532_ _0533_ _0535_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__a211o_1
XFILLER_0_41_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1553_ _0467_ _0475_ _0476_ _0437_ net48 VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__a32o_1
X_1484_ net44 VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2036_ clknet_leaf_25_clk _0008_ VGND VGND VPWR VPWR temperature_output\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_37_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0984_ net6 VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__buf_2
X_1536_ count\[1\] _0460_ _0461_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__a22o_1
X_1605_ net22 _0515_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__a21o_1
X_1398_ _0390_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__clkbuf_1
X_1467_ _0426_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2019_ clknet_leaf_20_clk _0259_ VGND VGND VPWR VPWR data_reg\[3\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xhold193 data_reg\[27\]\[3\] VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dlygate4sd3_1
Xhold171 data_reg\[24\]\[2\] VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__dlygate4sd3_1
Xhold160 data_reg\[14\]\[5\] VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold182 data_reg\[27\]\[6\] VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_5_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1321_ _0348_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__clkbuf_1
X_1252_ _0887_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_19_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1183_ _0730_ net138 _0846_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0967_ address\[4\] address\[3\] address\[2\] VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__and3_1
XFILLER_0_42_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1519_ net6 net211 _0451_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0898_ _0671_ net70 VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1870_ clknet_leaf_7_clk _0110_ VGND VGND VPWR VPWR data_reg\[6\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1166_ _0730_ net234 _0837_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__mux2_1
X_1304_ _0339_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__clkbuf_1
X_1235_ _0742_ net148 _0865_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__mux2_1
X_1097_ _0738_ net262 _0792_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__mux2_1
X_1999_ clknet_leaf_8_clk _0239_ VGND VGND VPWR VPWR data_reg\[30\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1020_ net158 net145 _0754_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1922_ clknet_leaf_19_clk _0162_ VGND VGND VPWR VPWR data_reg\[21\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_1784_ clknet_leaf_25_clk _0032_ VGND VGND VPWR VPWR data_reg\[15\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1853_ clknet_leaf_22_clk _0093_ VGND VGND VPWR VPWR data_reg\[12\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1149_ _0736_ net306 _0822_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1218_ net5 VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__buf_2
XFILLER_0_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold97 data_reg\[25\]\[0\] VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 data_reg\[7\]\[6\] VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 temperature_output\[15\] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 temperature_output\[14\] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 temperature_output\[5\] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 data_reg\[17\]\[6\] VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 count\[7\] VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dlygate4sd3_1
Xhold75 data_reg\[25\]\[6\] VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_58_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2052_ clknet_leaf_4_clk _0276_ VGND VGND VPWR VPWR count\[0\] sky130_fd_sc_hd__dfxtp_2
X_1003_ _0744_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__clkbuf_4
X_1905_ clknet_leaf_13_clk _0145_ VGND VGND VPWR VPWR data_reg\[11\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_32_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1767_ _0665_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1698_ data_reg\[0\]\[5\] data_reg\[1\]\[5\] data_reg\[2\]\[5\] data_reg\[3\]\[5\]
+ _0713_ _0516_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__mux4_1
XFILLER_0_12_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1836_ clknet_leaf_21_clk _0076_ VGND VGND VPWR VPWR data_reg\[9\]\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput21 net21 VGND VGND VPWR VPWR data_out[7] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1621_ data_reg\[29\]\[2\] _0787_ _0834_ data_reg\[30\]\[2\] _0534_ VGND VGND VPWR
+ VPWR _0535_ sky130_fd_sc_hd__a221o_1
X_1552_ count\[4\] _0470_ count\[5\] VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1483_ _0434_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2035_ clknet_leaf_2_clk _0275_ VGND VGND VPWR VPWR data_reg\[7\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1819_ clknet_leaf_4_clk _0059_ VGND VGND VPWR VPWR pulse_duration\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0983_ _0731_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
X_1535_ count\[1\] count\[0\] VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1604_ net25 _0517_ _0518_ _0708_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__a22o_1
X_1397_ net4 net126 _0389_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1466_ net216 net109 _0745_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2018_ clknet_leaf_23_clk _0258_ VGND VGND VPWR VPWR data_reg\[3\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold172 data_reg\[21\]\[0\] VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold161 data_reg\[8\]\[6\] VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__dlygate4sd3_1
Xhold183 data_reg\[8\]\[7\] VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dlygate4sd3_1
Xhold150 data_reg\[24\]\[6\] VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__dlygate4sd3_1
Xhold194 data_reg\[22\]\[1\] VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1320_ _0875_ net188 _0342_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_11_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1251_ _0886_ net221 _0879_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__mux2_1
X_1182_ _0847_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_19_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0897_ _0675_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
X_0966_ address\[1\] VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_58_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1449_ _0417_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__clkbuf_1
X_1518_ _0453_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_2_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1303_ _0875_ net90 _0333_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1096_ _0797_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1165_ _0838_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__clkbuf_1
X_1234_ _0877_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__clkbuf_1
X_1998_ clknet_leaf_7_clk _0238_ VGND VGND VPWR VPWR data_reg\[30\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0949_ _0702_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_38_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1921_ clknet_leaf_18_clk _0161_ VGND VGND VPWR VPWR data_reg\[21\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_1852_ clknet_leaf_23_clk _0092_ VGND VGND VPWR VPWR data_reg\[12\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_1783_ clknet_leaf_20_clk _0023_ VGND VGND VPWR VPWR data_reg\[1\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1079_ _0785_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_35_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1148_ _0826_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__clkbuf_1
X_1217_ _0866_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_58_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold98 data_reg\[28\]\[0\] VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dlygate4sd3_1
Xhold76 data_reg\[10\]\[5\] VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 count\[3\] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 data_reg\[5\]\[1\] VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 data_reg\[22\]\[5\] VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 pulse_duration\[0\] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 data_reg\[0\]\[7\] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 temperature_output\[8\] VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 temperature_output\[12\] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1002_ state net13 net12 VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__and3_1
X_2051_ clknet_leaf_20_clk _0007_ VGND VGND VPWR VPWR temperature_output\[15\] sky130_fd_sc_hd__dfxtp_1
X_1904_ clknet_leaf_11_clk _0144_ VGND VGND VPWR VPWR data_reg\[11\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1835_ clknet_leaf_8_clk _0075_ VGND VGND VPWR VPWR data_reg\[31\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1697_ data_reg\[4\]\[5\] data_reg\[5\]\[5\] data_reg\[6\]\[5\] data_reg\[7\]\[5\]
+ _0493_ _0516_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__mux4_1
X_1766_ net7 net274 _0661_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1620_ _0516_ _0503_ data_reg\[31\]\[2\] VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__and3_1
X_1551_ _0474_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__inv_2
X_1482_ net43 VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__clkbuf_1
X_2034_ clknet_leaf_1_clk _0274_ VGND VGND VPWR VPWR data_reg\[7\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1818_ clknet_leaf_5_clk _0058_ VGND VGND VPWR VPWR pulse_duration\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1749_ _0711_ _0654_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0982_ _0730_ net157 _0728_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__mux2_1
X_1534_ _0719_ _0462_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1465_ _0425_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__clkbuf_1
X_1603_ data_reg\[12\]\[1\] data_reg\[13\]\[1\] data_reg\[14\]\[1\] data_reg\[15\]\[1\]
+ _0713_ _0516_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__mux4_1
XFILLER_0_22_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1396_ _0727_ _0352_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__nand2_4
X_2017_ clknet_leaf_24_clk _0257_ VGND VGND VPWR VPWR data_reg\[3\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold162 data_reg\[28\]\[7\] VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__dlygate4sd3_1
Xhold140 count\[4\] VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__dlygate4sd3_1
Xhold151 data_reg\[10\]\[6\] VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__dlygate4sd3_1
Xhold173 data_reg\[27\]\[5\] VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__dlygate4sd3_1
Xhold184 data_reg\[9\]\[4\] VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__dlygate4sd3_1
Xhold195 data_reg\[9\]\[1\] VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1250_ net10 VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_19_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1181_ _0706_ net230 _0846_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0965_ _0711_ _0714_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__nand2_2
X_0896_ _0671_ net104 VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__and2_1
X_1448_ net4 net137 _0416_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__mux2_1
X_1517_ net5 net284 _0451_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1379_ _0791_ _0836_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__nand2_4
XFILLER_0_60_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1302_ _0338_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1233_ _0740_ net59 _0865_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__mux2_1
X_1095_ _0736_ net209 _0792_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__mux2_1
X_1164_ _0706_ net121 _0837_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__mux2_1
X_1997_ clknet_leaf_6_clk _0237_ VGND VGND VPWR VPWR data_reg\[30\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0948_ _0670_ net68 VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_13_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1920_ clknet_leaf_15_clk _0160_ VGND VGND VPWR VPWR data_reg\[21\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1851_ clknet_leaf_23_clk _0091_ VGND VGND VPWR VPWR data_reg\[13\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1782_ clknet_leaf_20_clk _0022_ VGND VGND VPWR VPWR data_reg\[1\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1216_ _0864_ net300 _0865_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__mux2_1
X_1078_ net39 VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1147_ _0734_ net269 _0822_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__mux2_1
Xhold22 data_reg\[31\]\[4\] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__dlygate4sd3_1
Xhold11 data_reg\[0\]\[3\] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_58_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold44 data_reg\[20\]\[2\] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 _0747_ VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 data_reg\[21\]\[1\] VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dlygate4sd3_1
Xhold77 temperature_output\[6\] VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 data_reg\[13\]\[6\] VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 data_reg\[10\]\[0\] VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dlygate4sd3_1
Xhold99 data_reg\[6\]\[6\] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2050_ clknet_leaf_24_clk _0006_ VGND VGND VPWR VPWR temperature_output\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1001_ _0743_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__clkbuf_1
X_1834_ clknet_leaf_7_clk _0074_ VGND VGND VPWR VPWR data_reg\[31\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_1765_ _0664_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_32_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1903_ clknet_leaf_17_clk _0143_ VGND VGND VPWR VPWR data_reg\[11\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1696_ data_reg\[8\]\[5\] data_reg\[9\]\[5\] data_reg\[10\]\[5\] data_reg\[11\]\[5\]
+ _0494_ _0495_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__mux4_1
XFILLER_0_12_167 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1550_ count\[5\] count\[4\] _0470_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__and3_1
XFILLER_0_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1481_ _0433_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__clkbuf_1
X_2033_ clknet_leaf_3_clk _0273_ VGND VGND VPWR VPWR data_reg\[7\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1817_ clknet_leaf_4_clk _0057_ VGND VGND VPWR VPWR pulse_duration\[1\] sky130_fd_sc_hd__dfxtp_1
X_1748_ _0706_ _0653_ _0655_ _0514_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__o211a_1
XFILLER_0_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1679_ _0709_ _0713_ data_reg\[31\]\[4\] VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__and3_1
XFILLER_0_23_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0981_ net5 VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_54_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1602_ data_reg\[16\]\[1\] data_reg\[17\]\[1\] data_reg\[18\]\[1\] data_reg\[19\]\[1\]
+ _0713_ _0516_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__mux4_1
XFILLER_0_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1533_ _0460_ _0461_ count\[0\] VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1395_ _0388_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__clkbuf_1
X_1464_ net213 net160 _0745_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__mux2_1
X_2016_ clknet_leaf_26_clk _0256_ VGND VGND VPWR VPWR data_reg\[3\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold185 data_reg\[24\]\[0\] VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dlygate4sd3_1
Xhold141 data_reg\[5\]\[2\] VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dlygate4sd3_1
Xhold163 data_reg\[23\]\[5\] VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__dlygate4sd3_1
Xhold174 data_reg\[10\]\[3\] VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__dlygate4sd3_1
Xhold130 temperature_output\[10\] VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dlygate4sd3_1
Xhold152 data_reg\[23\]\[6\] VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__dlygate4sd3_1
Xhold196 data_reg\[11\]\[6\] VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_21_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_21_clk sky130_fd_sc_hd__clkbuf_8
X_1180_ _0810_ net24 VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_19_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_12_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_12_clk sky130_fd_sc_hd__clkbuf_8
X_0964_ _0713_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_27_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1516_ _0452_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_10_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0895_ _0674_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
X_1447_ _0718_ _0836_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__nand2_4
XFILLER_0_4_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1378_ _0379_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1301_ _0873_ net267 _0333_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__mux2_1
X_1232_ _0876_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_1_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_1_clk sky130_fd_sc_hd__clkbuf_8
X_1163_ net23 _0836_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__nand2_4
X_1094_ _0796_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__clkbuf_1
X_1996_ clknet_leaf_6_clk _0236_ VGND VGND VPWR VPWR data_reg\[30\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_0947_ _0701_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_28_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1781_ clknet_leaf_24_clk _0021_ VGND VGND VPWR VPWR data_reg\[1\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_1850_ clknet_leaf_20_clk _0090_ VGND VGND VPWR VPWR data_reg\[13\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1215_ _0727_ net24 VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__nand2_4
X_1146_ _0825_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__clkbuf_1
X_1077_ _0784_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1979_ clknet_leaf_18_clk _0219_ VGND VGND VPWR VPWR data_reg\[27\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xhold12 data_reg\[31\]\[2\] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 count\[5\] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 data_reg\[19\]\[6\] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 data_reg\[4\]\[6\] VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 temperature_output\[4\] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 data_reg\[30\]\[5\] VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 data_reg\[6\]\[4\] VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dlygate4sd3_1
Xhold89 data_reg\[15\]\[4\] VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1000_ _0742_ net193 _0728_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__mux2_1
X_1902_ clknet_leaf_11_clk _0142_ VGND VGND VPWR VPWR data_reg\[11\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_32_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1833_ clknet_leaf_6_clk _0073_ VGND VGND VPWR VPWR data_reg\[31\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_1764_ net6 net246 _0661_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1695_ _0580_ _0606_ _0514_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__o21a_1
XFILLER_0_12_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1129_ _0815_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_46_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1480_ net34 VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__clkbuf_1
X_2032_ clknet_leaf_7_clk _0272_ VGND VGND VPWR VPWR data_reg\[7\]\[4\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_60_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1678_ data_reg\[24\]\[4\] _0532_ _0589_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1747_ _0714_ _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1816_ clknet_leaf_0_clk _0056_ VGND VGND VPWR VPWR pulse_duration\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0980_ _0729_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
X_1532_ net13 state VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__and2b_1
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1601_ address\[1\] VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__buf_4
XFILLER_0_22_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1463_ _0424_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__clkbuf_1
X_1394_ _0311_ net129 _0380_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2015_ clknet_leaf_20_clk _0255_ VGND VGND VPWR VPWR data_reg\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold197 data_reg\[26\]\[3\] VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dlygate4sd3_1
Xhold153 data_reg\[7\]\[4\] VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__dlygate4sd3_1
Xhold186 data_reg\[7\]\[2\] VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dlygate4sd3_1
Xhold175 data_reg\[21\]\[4\] VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__dlygate4sd3_1
Xhold164 data_reg\[20\]\[0\] VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__dlygate4sd3_1
Xhold120 pulse_duration\[7\] VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__dlygate4sd3_1
Xhold142 data_reg\[11\]\[7\] VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__dlygate4sd3_1
Xhold131 data_reg\[3\]\[2\] VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_59_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0894_ _0671_ net110 VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__and2_1
X_0963_ _0712_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_27_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1515_ net4 net96 _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_10_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1446_ _0415_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1377_ _0311_ net93 _0371_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_54_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1162_ _0835_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__clkbuf_8
X_1300_ _0337_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__clkbuf_1
X_1231_ _0875_ net307 _0865_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1093_ _0734_ net310 _0792_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__mux2_1
X_1995_ clknet_leaf_8_clk _0235_ VGND VGND VPWR VPWR data_reg\[29\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0946_ _0670_ net163 VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__and2_1
X_1429_ _0406_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_3_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1780_ clknet_leaf_26_clk _0020_ VGND VGND VPWR VPWR data_reg\[1\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1145_ _0732_ net152 _0822_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1214_ net4 VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__buf_2
X_1076_ net52 VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__clkbuf_1
X_0929_ _0692_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
X_1978_ clknet_leaf_17_clk _0218_ VGND VGND VPWR VPWR data_reg\[27\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xhold46 data_reg\[29\]\[1\] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 _0753_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 temperature_output\[9\] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__dlygate4sd3_1
Xhold79 temperature_output\[3\] VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 data_reg\[0\]\[1\] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 data_reg\[0\]\[2\] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__dlygate4sd3_1
Xhold68 data_reg\[26\]\[7\] VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1832_ clknet_leaf_7_clk _0072_ VGND VGND VPWR VPWR data_reg\[31\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1901_ clknet_leaf_10_clk _0141_ VGND VGND VPWR VPWR data_reg\[11\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1694_ _0587_ _0595_ _0605_ _0512_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_40_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1763_ _0663_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__clkbuf_1
X_1128_ _0734_ net286 _0811_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__mux2_1
X_1059_ _0775_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput14 net14 VGND VGND VPWR VPWR data_out[0] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_46_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2031_ clknet_leaf_5_clk _0271_ VGND VGND VPWR VPWR data_reg\[7\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1815_ clknet_leaf_20_clk _0031_ VGND VGND VPWR VPWR data_reg\[2\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_1677_ data_reg\[25\]\[4\] _0787_ _0834_ data_reg\[26\]\[4\] _0588_ VGND VGND VPWR
+ VPWR _0589_ sky130_fd_sc_hd__a221o_1
X_1746_ net2 _0721_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_32_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1462_ net11 net271 _0416_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__mux2_1
X_1531_ state net13 VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1600_ data_reg\[0\]\[1\] data_reg\[1\]\[1\] data_reg\[2\]\[1\] data_reg\[3\]\[1\]
+ _0494_ _0711_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__mux4_1
X_1393_ _0387_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__clkbuf_1
X_2014_ clknet_leaf_24_clk _0254_ VGND VGND VPWR VPWR data_reg\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold110 pulse_duration\[2\] VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dlygate4sd3_1
Xhold198 data_reg\[30\]\[6\] VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dlygate4sd3_1
Xhold165 data_reg\[26\]\[0\] VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__dlygate4sd3_1
Xhold187 data_reg\[15\]\[2\] VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dlygate4sd3_1
Xhold143 data_reg\[8\]\[3\] VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__dlygate4sd3_1
Xhold154 data_reg\[12\]\[0\] VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__dlygate4sd3_1
X_1729_ data_reg\[12\]\[7\] data_reg\[13\]\[7\] data_reg\[14\]\[7\] data_reg\[15\]\[7\]
+ _0712_ _0531_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__mux4_1
Xhold176 data_reg\[14\]\[7\] VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__dlygate4sd3_1
Xhold132 data_reg\[15\]\[1\] VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dlygate4sd3_1
Xhold121 data_reg\[26\]\[6\] VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_48_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_27_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0893_ _0673_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
X_0962_ address\[0\] VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__clkbuf_8
X_1445_ net11 net243 _0407_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__mux2_1
X_1514_ _0727_ net23 VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_10_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1376_ _0378_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1230_ net9 VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__buf_2
X_1092_ _0795_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__clkbuf_1
X_1161_ _0726_ _0834_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__and2b_1
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1994_ clknet_leaf_7_clk _0234_ VGND VGND VPWR VPWR data_reg\[29\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0945_ _0700_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
X_1428_ net11 net187 _0398_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1359_ _0369_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1213_ _0863_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__clkbuf_1
X_1075_ _0783_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__clkbuf_1
X_1144_ _0824_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__clkbuf_1
X_1977_ clknet_leaf_13_clk _0217_ VGND VGND VPWR VPWR data_reg\[27\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_43_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0928_ _0689_ net110 VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__and2_1
XFILLER_0_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold14 data_reg\[31\]\[7\] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__dlygate4sd3_1
Xhold58 data_reg\[11\]\[1\] VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 count\[6\] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 data_reg\[23\]\[2\] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__dlygate4sd3_1
Xhold69 data_reg\[21\]\[3\] VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 data_reg\[23\]\[4\] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_57_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1831_ clknet_leaf_8_clk _0071_ VGND VGND VPWR VPWR data_reg\[31\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1900_ clknet_leaf_21_clk _0140_ VGND VGND VPWR VPWR data_reg\[11\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1693_ _0756_ _0599_ _0604_ _0820_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__a211o_1
X_1762_ net5 net117 _0661_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__mux2_1
X_1127_ _0814_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__clkbuf_1
X_1058_ net109 net55 _0745_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput15 net15 VGND VGND VPWR VPWR data_out[1] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2030_ clknet_leaf_7_clk _0270_ VGND VGND VPWR VPWR data_reg\[7\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1745_ _0652_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__buf_2
X_1814_ clknet_leaf_24_clk _0030_ VGND VGND VPWR VPWR data_reg\[2\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_1676_ _0516_ _0503_ data_reg\[27\]\[4\] _0756_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_24_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_24_clk sky130_fd_sc_hd__clkbuf_8
X_1461_ _0423_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_38_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1530_ _0459_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1392_ _0886_ net176 _0380_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__mux2_1
X_2013_ clknet_leaf_24_clk _0253_ VGND VGND VPWR VPWR data_reg\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_15_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_15_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_9_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold111 _0749_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dlygate4sd3_1
Xhold100 data_reg\[26\]\[2\] VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_45_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1728_ data_reg\[20\]\[7\] data_reg\[21\]\[7\] data_reg\[22\]\[7\] data_reg\[23\]\[7\]
+ address\[0\] address\[1\] VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__mux4_1
Xhold144 data_reg\[14\]\[0\] VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__dlygate4sd3_1
Xhold122 data_reg\[11\]\[0\] VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__dlygate4sd3_1
Xhold133 data_reg\[4\]\[7\] VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlygate4sd3_1
X_1659_ data_reg\[4\]\[3\] data_reg\[5\]\[3\] data_reg\[6\]\[3\] data_reg\[7\]\[3\]
+ _0494_ _0495_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__mux4_1
Xhold177 data_reg\[8\]\[1\] VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dlygate4sd3_1
Xhold199 data_reg\[13\]\[3\] VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold166 data_reg\[13\]\[0\] VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__dlygate4sd3_1
Xhold188 data_reg\[3\]\[0\] VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dlygate4sd3_1
Xhold155 data_reg\[18\]\[0\] VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_27_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0961_ _0710_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__buf_4
XFILLER_0_54_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0892_ _0671_ net84 VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_10_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1444_ _0414_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_4_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_4_clk sky130_fd_sc_hd__clkbuf_8
X_1513_ _0450_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__clkbuf_1
X_1375_ _0886_ net146 _0371_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1091_ _0732_ net245 _0792_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__mux2_1
X_1160_ _0833_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1993_ clknet_leaf_6_clk _0233_ VGND VGND VPWR VPWR data_reg\[29\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_51_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0944_ _0670_ net155 VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__and2_1
XFILLER_0_15_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1427_ _0405_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__clkbuf_1
X_1358_ _0886_ net100 _0362_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__mux2_1
X_1289_ _0331_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_21_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1212_ _0742_ net204 _0855_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__mux2_1
X_1074_ net42 VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1143_ _0730_ net285 _0822_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__mux2_1
X_1976_ clknet_leaf_11_clk _0216_ VGND VGND VPWR VPWR data_reg\[27\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_43_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0927_ _0691_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold48 data_reg\[20\]\[5\] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 temperature_output\[7\] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__dlygate4sd3_1
Xhold59 temperature_output\[1\] VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 count\[10\] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 count\[8\] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_57_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1830_ clknet_leaf_7_clk _0070_ VGND VGND VPWR VPWR data_reg\[31\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_40_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1761_ _0662_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1692_ _0601_ _0603_ _0548_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__o21a_1
XFILLER_0_12_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1126_ _0732_ net250 _0811_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__mux2_1
X_1057_ _0774_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__clkbuf_1
X_1959_ clknet_leaf_12_clk _0199_ VGND VGND VPWR VPWR data_reg\[26\]\[3\] sky130_fd_sc_hd__dfxtp_1
Xoutput16 net16 VGND VGND VPWR VPWR data_out[2] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_54_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_60_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1744_ net2 _0721_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__or2_1
X_1813_ clknet_leaf_24_clk _0029_ VGND VGND VPWR VPWR data_reg\[2\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_1675_ _0557_ _0583_ _0586_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__and3_1
XFILLER_0_40_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1109_ _0804_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1460_ net10 net223 _0416_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__mux2_1
X_1391_ _0386_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2012_ clknet_leaf_1_clk _0252_ VGND VGND VPWR VPWR data_reg\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1727_ _0636_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__clkbuf_1
Xhold167 data_reg\[25\]\[4\] VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__dlygate4sd3_1
Xhold112 data_reg\[30\]\[0\] VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dlygate4sd3_1
Xhold145 data_reg\[11\]\[2\] VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dlygate4sd3_1
Xhold101 data_reg\[27\]\[0\] VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dlygate4sd3_1
Xhold156 data_reg\[24\]\[1\] VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__dlygate4sd3_1
X_1658_ _0552_ _0569_ _0570_ _0550_ _0756_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__a221o_1
XFILLER_0_13_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold134 data_reg\[27\]\[7\] VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dlygate4sd3_1
Xhold123 data_reg\[19\]\[7\] VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__dlygate4sd3_1
Xhold178 data_reg\[29\]\[0\] VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__dlygate4sd3_1
Xhold189 data_reg\[22\]\[0\] VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1589_ _0791_ _0501_ _0504_ _0708_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__a22o_1
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0960_ _0709_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__buf_4
XFILLER_0_49_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0891_ _0672_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
X_1512_ net11 net208 _0442_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__mux2_1
X_1374_ _0377_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__clkbuf_1
X_1443_ net10 net292 _0407_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1090_ _0794_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__clkbuf_1
X_1992_ clknet_leaf_8_clk _0232_ VGND VGND VPWR VPWR data_reg\[29\]\[4\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_41_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0943_ _0699_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_15_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1357_ _0368_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__clkbuf_1
X_1426_ net10 net233 _0398_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_50_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1288_ _0886_ net149 _0324_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_38_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1142_ _0823_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__clkbuf_1
X_1211_ _0862_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__clkbuf_1
X_1073_ _0782_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1975_ clknet_leaf_12_clk _0215_ VGND VGND VPWR VPWR data_reg\[27\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0926_ _0689_ net84 VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold27 data_reg\[31\]\[6\] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 data_reg\[10\]\[4\] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__dlygate4sd3_1
X_1409_ _0886_ net207 _0389_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__mux2_1
Xhold16 _0284_ VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__dlygate4sd3_1
Xhold49 data_reg\[7\]\[5\] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_7_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1691_ _0831_ _0549_ _0602_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_40_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1760_ net4 net169 _0661_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1125_ _0813_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__clkbuf_1
X_1056_ net160 net40 _0754_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__mux2_1
Xoutput17 net17 VGND VGND VPWR VPWR data_out[3] sky130_fd_sc_hd__clkbuf_4
X_1958_ clknet_leaf_13_clk _0198_ VGND VGND VPWR VPWR data_reg\[26\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1889_ clknet_leaf_16_clk _0129_ VGND VGND VPWR VPWR data_reg\[18\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_0909_ _0679_ net60 VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_54_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1743_ _0651_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__clkbuf_1
X_1674_ data_reg\[21\]\[4\] _0787_ _0585_ _0548_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__a211o_1
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1812_ clknet_leaf_1_clk _0028_ VGND VGND VPWR VPWR data_reg\[2\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1108_ _0732_ net127 _0801_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1039_ _0765_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_51_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1390_ _0875_ net101 _0380_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2011_ clknet_leaf_26_clk _0251_ VGND VGND VPWR VPWR data_reg\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1726_ _0679_ _0635_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__and2_1
Xhold157 data_reg\[10\]\[1\] VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__dlygate4sd3_1
Xhold102 data_reg\[13\]\[2\] VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dlygate4sd3_1
X_1657_ data_reg\[16\]\[3\] data_reg\[17\]\[3\] data_reg\[18\]\[3\] data_reg\[19\]\[3\]
+ _0714_ _0711_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__mux4_1
Xhold146 data_reg\[15\]\[6\] VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dlygate4sd3_1
X_1588_ data_reg\[12\]\[0\] data_reg\[13\]\[0\] data_reg\[14\]\[0\] data_reg\[15\]\[0\]
+ _0503_ _0710_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__mux4_1
Xhold168 data_reg\[15\]\[7\] VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__dlygate4sd3_1
Xhold124 data_reg\[21\]\[6\] VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dlygate4sd3_1
Xhold179 data_reg\[18\]\[7\] VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__dlygate4sd3_1
Xhold113 data_reg\[16\]\[1\] VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dlygate4sd3_1
Xhold135 pulse_duration\[8\] VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_48_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_36_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_58 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0890_ _0671_ net64 VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__and2_1
X_1442_ _0413_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__clkbuf_1
X_1511_ _0449_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__clkbuf_1
X_1373_ _0875_ net140 _0371_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_18_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1709_ address\[5\] net2 _0611_ _0619_ _0512_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_24_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1991_ clknet_leaf_8_clk _0231_ VGND VGND VPWR VPWR data_reg\[29\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_51_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0942_ _0670_ net60 VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__and2_1
XFILLER_0_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1425_ _0404_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1356_ _0875_ net183 _0362_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_38_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1287_ _0330_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1072_ net47 VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1141_ _0706_ net272 _0822_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1210_ _0740_ net283 _0855_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__mux2_1
X_1974_ clknet_leaf_13_clk _0214_ VGND VGND VPWR VPWR data_reg\[27\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0925_ _0690_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
X_1408_ _0395_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__clkbuf_1
Xhold17 data_reg\[31\]\[5\] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold28 count\[2\] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__dlygate4sd3_1
Xhold39 temperature_output\[0\] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__dlygate4sd3_1
X_1339_ _0875_ net164 _0353_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_57_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1690_ data_reg\[8\]\[4\] data_reg\[9\]\[4\] data_reg\[10\]\[4\] data_reg\[11\]\[4\]
+ _0502_ _0716_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__mux4_1
XFILLER_0_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1055_ _0773_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__clkbuf_1
X_1124_ _0730_ net172 _0811_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__mux2_1
X_1957_ clknet_leaf_14_clk _0197_ VGND VGND VPWR VPWR data_reg\[26\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput18 net18 VGND VGND VPWR VPWR data_out[4] sky130_fd_sc_hd__clkbuf_4
X_1888_ clknet_leaf_2_clk _0128_ VGND VGND VPWR VPWR data_reg\[18\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_0908_ _0681_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_54_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1811_ clknet_leaf_25_clk _0027_ VGND VGND VPWR VPWR data_reg\[2\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_1742_ _0689_ _0650_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__and2_1
X_1673_ data_reg\[20\]\[4\] _0532_ _0834_ data_reg\[22\]\[4\] _0584_ VGND VGND VPWR
+ VPWR _0585_ sky130_fd_sc_hd__a221o_1
XFILLER_0_7_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_18_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_18_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1107_ _0803_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__clkbuf_1
X_1038_ _0742_ net297 _0757_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2010_ clknet_leaf_25_clk _0250_ VGND VGND VPWR VPWR data_reg\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_57_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1725_ net1 _0549_ _0634_ _0490_ net20 VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__a32o_1
Xhold158 data_reg\[25\]\[5\] VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__dlygate4sd3_1
Xhold169 data_reg\[27\]\[2\] VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_7_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_7_clk sky130_fd_sc_hd__clkbuf_8
Xhold114 data_reg\[11\]\[5\] VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__dlygate4sd3_1
Xhold103 data_reg\[8\]\[5\] VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dlygate4sd3_1
Xhold136 data_reg\[6\]\[5\] VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlygate4sd3_1
X_1656_ data_reg\[0\]\[3\] data_reg\[1\]\[3\] data_reg\[2\]\[3\] data_reg\[3\]\[3\]
+ _0494_ _0495_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__mux4_2
Xhold125 data_reg\[8\]\[0\] VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dlygate4sd3_1
Xhold147 data_reg\[12\]\[1\] VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__dlygate4sd3_1
X_1587_ _0502_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__buf_4
XFILLER_0_36_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1441_ net9 net97 _0407_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1510_ net10 net186 _0442_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__mux2_1
X_1372_ _0376_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_18_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1708_ _0314_ _0612_ _0615_ _0618_ _0510_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__a2111o_1
X_1639_ data_reg\[0\]\[2\] data_reg\[1\]\[2\] data_reg\[2\]\[2\] data_reg\[3\]\[2\]
+ _0503_ _0710_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__mux4_2
XFILLER_0_36_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1990_ clknet_leaf_7_clk _0230_ VGND VGND VPWR VPWR data_reg\[29\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_51_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0941_ _0698_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1355_ _0367_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_1
X_1424_ net9 net248 _0398_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_38_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1286_ _0875_ net130 _0324_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_21_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1071_ _0781_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__clkbuf_1
X_1140_ _0789_ net25 VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__nand2_4
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1973_ clknet_leaf_14_clk _0213_ VGND VGND VPWR VPWR data_reg\[27\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_35_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0924_ _0689_ net64 VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__and2_1
XFILLER_0_55_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1407_ net9 net198 _0389_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__mux2_1
X_1338_ _0358_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__clkbuf_1
Xhold29 _0278_ VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold18 data_reg\[0\]\[5\] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__dlygate4sd3_1
X_1269_ _0875_ net73 _0315_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_57_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1123_ _0812_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__clkbuf_1
X_1054_ net145 count\[7\] _0754_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__mux2_1
X_1956_ clknet_leaf_14_clk _0196_ VGND VGND VPWR VPWR data_reg\[26\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_1887_ clknet_leaf_2_clk _0127_ VGND VGND VPWR VPWR data_reg\[18\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0907_ _0679_ net79 VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__and2_1
Xoutput19 net19 VGND VGND VPWR VPWR data_out[5] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_54_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1741_ net1 _0549_ _0649_ _0490_ net21 VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__a32o_1
XFILLER_0_4_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1810_ clknet_leaf_25_clk _0026_ VGND VGND VPWR VPWR data_reg\[2\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_1672_ _0709_ _0713_ data_reg\[23\]\[4\] VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__and3_1
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1106_ _0730_ net115 _0801_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_51_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2086_ clknet_leaf_23_clk _0310_ VGND VGND VPWR VPWR data_reg\[14\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_1037_ _0764_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1939_ clknet_leaf_19_clk _0179_ VGND VGND VPWR VPWR data_reg\[23\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold115 data_reg\[26\]\[5\] VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__dlygate4sd3_1
X_1724_ _0624_ _0627_ _0630_ _0633_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__or4_2
Xhold104 data_reg\[10\]\[7\] VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dlygate4sd3_1
Xhold126 data_reg\[20\]\[7\] VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dlygate4sd3_1
Xhold148 data_reg\[25\]\[2\] VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__dlygate4sd3_1
X_1655_ _0510_ _0567_ _0831_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__o21a_1
Xhold159 data_reg\[20\]\[3\] VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold137 data_reg\[23\]\[7\] VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dlygate4sd3_1
X_1586_ address\[0\] VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__clkbuf_8
X_2069_ clknet_leaf_11_clk _0293_ VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1440_ _0412_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__clkbuf_1
X_1371_ _0873_ net252 _0371_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1638_ _0820_ _0510_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__nor2_1
X_1707_ net25 _0616_ _0617_ _0718_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__a22o_1
X_1569_ _0671_ _0486_ _0487_ _0437_ net51 VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__a32o_1
XFILLER_0_55_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0940_ _0689_ net79 VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__and2_1
XFILLER_0_42_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1423_ _0403_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__clkbuf_1
X_1354_ _0873_ net192 _0362_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__mux2_1
X_1285_ _0329_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_38_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1070_ net31 VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1972_ clknet_leaf_12_clk _0212_ VGND VGND VPWR VPWR data_reg\[27\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_0923_ net12 VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_7_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1337_ _0873_ net275 _0353_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__mux2_1
X_1406_ _0394_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1268_ _0320_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__clkbuf_1
Xhold19 data_reg\[0\]\[6\] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__dlygate4sd3_1
X_1199_ _0856_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1122_ _0706_ net179 _0811_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1053_ _0772_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1886_ clknet_leaf_2_clk _0126_ VGND VGND VPWR VPWR data_reg\[18\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0906_ _0680_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
X_1955_ clknet_leaf_18_clk _0195_ VGND VGND VPWR VPWR data_reg\[25\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_45_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1671_ data_reg\[17\]\[4\] _0787_ _0582_ _0756_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__a211o_1
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1740_ _0639_ _0642_ _0645_ _0648_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__or4_2
XFILLER_0_40_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1105_ _0802_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__clkbuf_1
X_2085_ clknet_leaf_23_clk _0309_ VGND VGND VPWR VPWR data_reg\[14\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_51_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1036_ _0740_ net261 _0757_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__mux2_1
X_1869_ clknet_leaf_4_clk _0109_ VGND VGND VPWR VPWR data_reg\[6\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1938_ clknet_leaf_19_clk _0178_ VGND VGND VPWR VPWR data_reg\[23\]\[6\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_48_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_57_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1654_ _0562_ _0563_ _0820_ _0566_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__o211a_1
Xhold149 data_reg\[13\]\[5\] VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__dlygate4sd3_1
Xhold127 data_reg\[17\]\[2\] VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dlygate4sd3_1
Xhold105 data_reg\[21\]\[5\] VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dlygate4sd3_1
Xhold138 temperature_output\[11\] VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlygate4sd3_1
Xhold116 data_reg\[22\]\[7\] VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__dlygate4sd3_1
X_1723_ _0718_ _0631_ _0632_ net25 VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1585_ data_reg\[8\]\[0\] data_reg\[9\]\[0\] data_reg\[10\]\[0\] data_reg\[11\]\[0\]
+ _0713_ _0710_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__mux4_1
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2068_ clknet_leaf_11_clk _0292_ VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__dfxtp_1
X_1019_ _0745_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1370_ _0375_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1706_ data_reg\[28\]\[5\] data_reg\[29\]\[5\] data_reg\[30\]\[5\] data_reg\[31\]\[5\]
+ _0493_ _0516_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__mux4_2
X_1637_ data_reg\[16\]\[2\] data_reg\[17\]\[2\] data_reg\[18\]\[2\] data_reg\[19\]\[2\]
+ _0503_ _0710_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__mux4_1
XFILLER_0_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1568_ count\[10\] _0484_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__or2_1
X_1499_ _0443_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1422_ net8 net295 _0398_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1353_ _0366_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1284_ _0873_ net200 _0324_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0999_ net11 VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__buf_2
XFILLER_0_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0922_ _0688_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1971_ clknet_leaf_20_clk _0211_ VGND VGND VPWR VPWR data_reg\[10\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_1405_ net8 net296 _0389_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput1 EN VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_2
X_1336_ _0357_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__clkbuf_1
X_1267_ _0873_ net290 _0315_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__mux2_1
X_1198_ _0706_ net180 _0855_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_27_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1121_ _0708_ _0810_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__nand2_4
X_1052_ net301 count\[6\] _0754_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__mux2_1
XFILLER_0_22_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1954_ clknet_leaf_17_clk _0194_ VGND VGND VPWR VPWR data_reg\[25\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0905_ _0679_ net62 VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__and2_1
X_1885_ clknet_leaf_21_clk _0125_ VGND VGND VPWR VPWR data_reg\[18\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1319_ _0347_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1670_ data_reg\[16\]\[4\] _0532_ _0834_ data_reg\[18\]\[4\] _0581_ VGND VGND VPWR
+ VPWR _0582_ sky130_fd_sc_hd__a221o_1
XFILLER_0_7_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2084_ clknet_leaf_3_clk _0308_ VGND VGND VPWR VPWR data_reg\[14\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_1035_ _0763_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__clkbuf_1
X_1104_ _0706_ net191 _0801_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_51_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1937_ clknet_leaf_18_clk _0177_ VGND VGND VPWR VPWR data_reg\[23\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_1868_ clknet_leaf_3_clk _0108_ VGND VGND VPWR VPWR data_reg\[6\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_1799_ clknet_leaf_0_clk _0047_ VGND VGND VPWR VPWR data_reg\[4\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_58_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold139 data_reg\[24\]\[5\] VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__dlygate4sd3_1
X_1653_ data_reg\[24\]\[3\] _0532_ _0565_ _0756_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__a211o_1
Xhold117 data_reg\[25\]\[1\] VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__dlygate4sd3_1
X_1584_ data_reg\[16\]\[0\] data_reg\[17\]\[0\] data_reg\[18\]\[0\] data_reg\[19\]\[0\]
+ _0714_ _0711_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__mux4_1
Xhold106 data_reg\[23\]\[3\] VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold128 data_reg\[3\]\[3\] VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_21_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1722_ data_reg\[16\]\[6\] data_reg\[17\]\[6\] data_reg\[18\]\[6\] data_reg\[19\]\[6\]
+ _0502_ _0709_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__mux4_1
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2067_ clknet_leaf_11_clk _0291_ VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__dfxtp_1
X_1018_ net82 VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_14_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_4_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1705_ data_reg\[16\]\[5\] data_reg\[17\]\[5\] data_reg\[18\]\[5\] data_reg\[19\]\[5\]
+ _0493_ _0716_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__mux4_1
XFILLER_0_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1636_ _0820_ _0549_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__and2_2
X_1567_ count\[10\] _0484_ _0461_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_1_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1498_ net4 net150 _0442_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1421_ _0402_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1352_ _0871_ net291 _0362_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__mux2_1
X_1283_ _0328_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0998_ _0741_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1619_ _0820_ _0831_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0921_ _0679_ net67 VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__and2_1
X_1970_ clknet_leaf_20_clk _0210_ VGND VGND VPWR VPWR data_reg\[10\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1404_ _0393_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1335_ _0871_ net232 _0353_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput2 RS VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_2
X_1197_ _0821_ _0836_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__nand2_4
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1266_ _0319_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_2_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1120_ _0723_ _0726_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__nor2_8
X_1051_ _0771_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__clkbuf_1
X_1953_ clknet_leaf_13_clk _0193_ VGND VGND VPWR VPWR data_reg\[25\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1884_ clknet_leaf_21_clk _0124_ VGND VGND VPWR VPWR data_reg\[18\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0904_ _0670_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__clkbuf_4
X_1318_ _0873_ net72 _0342_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__mux2_1
X_1249_ _0885_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2083_ clknet_leaf_7_clk _0307_ VGND VGND VPWR VPWR data_reg\[14\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1103_ _0708_ _0789_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__nand2_4
X_1034_ _0738_ net268 _0757_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__mux2_1
X_1936_ clknet_leaf_15_clk _0176_ VGND VGND VPWR VPWR data_reg\[23\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1867_ clknet_leaf_22_clk _0107_ VGND VGND VPWR VPWR data_reg\[17\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_1798_ clknet_leaf_0_clk _0046_ VGND VGND VPWR VPWR data_reg\[4\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1721_ data_reg\[28\]\[6\] data_reg\[29\]\[6\] data_reg\[30\]\[6\] data_reg\[31\]\[6\]
+ _0712_ _0709_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__mux4_2
XFILLER_0_13_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1652_ data_reg\[25\]\[3\] _0787_ _0834_ data_reg\[26\]\[3\] _0564_ VGND VGND VPWR
+ VPWR _0565_ sky130_fd_sc_hd__a221o_1
Xhold118 pulse_duration\[4\] VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__dlygate4sd3_1
X_1583_ _0352_ _0492_ _0498_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__a21o_1
Xhold107 data_reg\[22\]\[3\] VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dlygate4sd3_1
Xhold129 _0428_ VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_28_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2066_ clknet_leaf_8_clk _0290_ VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1017_ net81 pulse_duration\[6\] _0746_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1919_ clknet_leaf_17_clk _0159_ VGND VGND VPWR VPWR data_reg\[21\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_31_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1704_ _0708_ _0613_ _0614_ _0352_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1635_ net3 net2 VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__and2b_1
X_1497_ _0791_ _0810_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__nand2_4
X_1566_ _0484_ _0485_ net55 _0437_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__a2bb2o_1
X_2049_ clknet_leaf_24_clk _0005_ VGND VGND VPWR VPWR temperature_output\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1420_ net7 net270 _0398_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__mux2_1
X_1351_ _0365_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1282_ _0871_ net94 _0324_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1618_ _0531_ _0493_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__nor2_4
XFILLER_0_1_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0997_ _0740_ net171 _0728_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__mux2_1
X_1549_ _0467_ _0472_ _0473_ _0437_ net165 VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_29_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_37_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold290 data_reg\[19\]\[2\] VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0920_ _0687_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1403_ net7 net218 _0389_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__mux2_1
X_1334_ _0356_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__clkbuf_1
X_1265_ _0871_ net184 _0315_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 RW VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_34_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1196_ _0854_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1050_ net231 count\[5\] _0754_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__mux2_1
X_1952_ clknet_leaf_12_clk _0192_ VGND VGND VPWR VPWR data_reg\[25\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0903_ _0678_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
X_1883_ clknet_leaf_21_clk _0123_ VGND VGND VPWR VPWR data_reg\[16\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_1248_ _0875_ net139 _0879_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__mux2_1
X_1317_ _0346_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1179_ _0845_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2082_ clknet_leaf_2_clk _0306_ VGND VGND VPWR VPWR data_reg\[14\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_1102_ _0800_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__clkbuf_1
X_1033_ _0762_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__clkbuf_1
X_1797_ clknet_leaf_4_clk _0045_ VGND VGND VPWR VPWR data_reg\[4\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1935_ clknet_leaf_17_clk _0175_ VGND VGND VPWR VPWR data_reg\[23\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_1866_ clknet_leaf_22_clk _0106_ VGND VGND VPWR VPWR data_reg\[17\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_50_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1651_ _0716_ _0713_ data_reg\[27\]\[3\] VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_44_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold108 data_reg\[20\]\[1\] VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dlygate4sd3_1
X_1720_ _0352_ _0628_ _0629_ _0832_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__a22o_1
Xhold119 _0751_ VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__dlygate4sd3_1
X_1582_ _0314_ _0496_ _0497_ _0718_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__a22o_1
X_2065_ clknet_leaf_8_clk _0289_ VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_53_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1016_ _0752_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__clkbuf_1
X_1849_ clknet_leaf_3_clk _0089_ VGND VGND VPWR VPWR data_reg\[13\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_1918_ clknet_leaf_14_clk _0158_ VGND VGND VPWR VPWR data_reg\[21\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_20_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_20_clk sky130_fd_sc_hd__clkbuf_8
X_1703_ data_reg\[24\]\[5\] data_reg\[25\]\[5\] data_reg\[26\]\[5\] data_reg\[27\]\[5\]
+ _0493_ _0516_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__mux4_2
Xclkbuf_leaf_11_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_11_clk sky130_fd_sc_hd__clkbuf_8
X_1634_ _0756_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__inv_2
XFILLER_0_5_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1496_ _0441_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__clkbuf_1
X_1565_ count\[9\] _0481_ _0467_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_1_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2048_ clknet_leaf_26_clk _0004_ VGND VGND VPWR VPWR temperature_output\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_23_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1350_ _0869_ net173 _0362_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__mux2_1
X_1281_ _0327_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_0_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_58_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0996_ net10 VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__buf_2
XFILLER_0_41_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1617_ address\[1\] VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__buf_4
X_1548_ count\[4\] _0470_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__or2_1
X_1479_ _0432_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_37_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold280 data_reg\[16\]\[4\] VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__dlygate4sd3_1
Xhold291 data_reg\[18\]\[4\] VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1402_ _0392_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput4 data_in[0] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_4
X_1333_ _0869_ net196 _0353_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__mux2_1
X_1264_ _0318_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1195_ _0742_ net265 _0846_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0979_ _0706_ net282 _0728_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1951_ clknet_leaf_12_clk _0191_ VGND VGND VPWR VPWR data_reg\[25\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_31_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0902_ _0671_ net102 VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1882_ clknet_leaf_21_clk _0122_ VGND VGND VPWR VPWR data_reg\[16\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1247_ _0884_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1316_ _0871_ net131 _0342_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1178_ _0742_ net253 _0837_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_53_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap22 _0507_ VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1032_ _0736_ net294 _0757_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__mux2_1
X_2081_ clknet_leaf_8_clk _0305_ VGND VGND VPWR VPWR data_reg\[14\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_1101_ _0742_ net309 _0792_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1934_ clknet_leaf_15_clk _0174_ VGND VGND VPWR VPWR data_reg\[23\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1796_ clknet_leaf_5_clk _0044_ VGND VGND VPWR VPWR data_reg\[4\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1865_ clknet_leaf_16_clk _0105_ VGND VGND VPWR VPWR data_reg\[17\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_50_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1650_ data_reg\[28\]\[3\] _0532_ _0548_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__a21o_1
XFILLER_0_53_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1581_ data_reg\[28\]\[0\] data_reg\[29\]\[0\] data_reg\[30\]\[0\] data_reg\[31\]\[0\]
+ _0494_ _0495_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__mux4_2
Xhold109 data_reg\[24\]\[7\] VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1015_ net237 net231 _0746_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__mux2_1
X_2064_ clknet_leaf_0_clk _0288_ VGND VGND VPWR VPWR state sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1917_ clknet_leaf_18_clk _0157_ VGND VGND VPWR VPWR data_reg\[21\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_1848_ clknet_leaf_3_clk _0088_ VGND VGND VPWR VPWR data_reg\[13\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1779_ clknet_leaf_25_clk _0019_ VGND VGND VPWR VPWR data_reg\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_4_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1633_ _0536_ _0539_ _0543_ _0546_ _0510_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__a41o_1
X_1702_ data_reg\[12\]\[5\] data_reg\[13\]\[5\] data_reg\[14\]\[5\] data_reg\[15\]\[5\]
+ _0502_ _0716_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__mux4_1
XFILLER_0_5_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1564_ count\[9\] _0481_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__and2_1
X_1495_ _0746_ net105 VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_18_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2047_ clknet_leaf_25_clk _0003_ VGND VGND VPWR VPWR temperature_output\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1280_ _0869_ net293 _0324_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0995_ _0739_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1616_ _0719_ _0530_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__nor2_1
XFILLER_0_41_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1547_ count\[4\] _0470_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__nand2_1
X_1478_ net36 VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_37_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold270 data_reg\[28\]\[4\] VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__dlygate4sd3_1
Xhold281 data_reg\[17\]\[4\] VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1401_ net6 net194 _0389_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__mux2_1
Xinput5 data_in[1] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_4
X_1332_ _0355_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__clkbuf_1
X_1263_ _0869_ net69 _0315_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__mux2_1
X_1194_ _0853_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_34_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0978_ _0708_ _0727_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__nand2_4
XFILLER_0_6_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1950_ clknet_leaf_13_clk _0190_ VGND VGND VPWR VPWR data_reg\[25\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_31_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1881_ clknet_leaf_16_clk _0121_ VGND VGND VPWR VPWR data_reg\[16\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_0901_ _0677_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_22_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1315_ _0345_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1246_ _0873_ net87 _0879_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1177_ _0844_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_6_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1031_ _0761_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
X_1100_ _0799_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2080_ clknet_leaf_1_clk _0304_ VGND VGND VPWR VPWR data_reg\[14\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1933_ clknet_leaf_18_clk _0173_ VGND VGND VPWR VPWR data_reg\[23\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_58_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1795_ clknet_leaf_5_clk _0043_ VGND VGND VPWR VPWR data_reg\[4\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_1864_ clknet_leaf_16_clk _0104_ VGND VGND VPWR VPWR data_reg\[17\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1229_ _0874_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_50_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1580_ data_reg\[20\]\[0\] data_reg\[21\]\[0\] data_reg\[22\]\[0\] data_reg\[23\]\[0\]
+ _0494_ _0495_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__mux4_1
XFILLER_0_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1014_ net144 VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2063_ clknet_leaf_26_clk _0287_ VGND VGND VPWR VPWR count\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1916_ clknet_leaf_14_clk _0156_ VGND VGND VPWR VPWR data_reg\[21\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_1847_ clknet_leaf_2_clk _0087_ VGND VGND VPWR VPWR data_reg\[13\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_1778_ clknet_leaf_25_clk _0018_ VGND VGND VPWR VPWR data_reg\[1\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1701_ data_reg\[20\]\[5\] data_reg\[21\]\[5\] data_reg\[22\]\[5\] data_reg\[23\]\[5\]
+ _0494_ _0495_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__mux4_1
XFILLER_0_14_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1632_ data_reg\[14\]\[2\] _0834_ _0544_ _0545_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__a211o_1
XFILLER_0_39_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1494_ _0440_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__clkbuf_1
X_1563_ net40 _0437_ _0467_ _0483_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_1_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2046_ clknet_leaf_25_clk _0002_ VGND VGND VPWR VPWR temperature_output\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0994_ _0738_ net225 _0728_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1615_ net27 _0490_ _0529_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__a21oi_1
X_1546_ _0470_ _0471_ net46 _0437_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_5_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1477_ _0431_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_59_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2029_ clknet_leaf_4_clk _0269_ VGND VGND VPWR VPWR data_reg\[7\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xhold271 data_reg\[27\]\[4\] VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__dlygate4sd3_1
Xhold260 data_reg\[17\]\[1\] VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__dlygate4sd3_1
Xhold282 data_reg\[19\]\[5\] VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1400_ _0391_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__clkbuf_1
X_1331_ _0867_ net181 _0353_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__mux2_1
Xinput6 data_in[2] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_2
X_1193_ _0740_ net254 _0846_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__mux2_1
X_1262_ _0317_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0977_ _0715_ _0726_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__nor2_8
XFILLER_0_6_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1529_ net11 net244 _0451_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1880_ clknet_leaf_16_clk _0120_ VGND VGND VPWR VPWR data_reg\[16\]\[4\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0900_ _0671_ net56 VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1314_ _0869_ net61 _0342_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_22_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1245_ _0883_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1176_ _0740_ net124 _0837_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap24 net25 VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_10_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1030_ _0734_ net206 _0757_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__mux2_1
X_1932_ clknet_leaf_14_clk _0172_ VGND VGND VPWR VPWR data_reg\[23\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1863_ clknet_leaf_2_clk _0103_ VGND VGND VPWR VPWR data_reg\[17\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1794_ clknet_leaf_5_clk _0042_ VGND VGND VPWR VPWR data_reg\[4\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1228_ _0873_ net257 _0865_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1159_ address\[0\] address\[1\] VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__and2b_1
XFILLER_0_30_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_23_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_23_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2062_ clknet_leaf_0_clk _0286_ VGND VGND VPWR VPWR count\[10\] sky130_fd_sc_hd__dfxtp_1
X_1013_ data_reg\[4\]\[4\] net143 _0746_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1846_ clknet_leaf_9_clk _0086_ VGND VGND VPWR VPWR data_reg\[13\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_14_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_14_clk sky130_fd_sc_hd__clkbuf_8
X_1777_ clknet_leaf_24_clk _0017_ VGND VGND VPWR VPWR data_reg\[1\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_1915_ clknet_leaf_19_clk _0155_ VGND VGND VPWR VPWR data_reg\[20\]\[7\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_40_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1631_ data_reg\[12\]\[2\] _0532_ _0787_ data_reg\[13\]\[2\] VGND VGND VPWR VPWR
+ _0545_ sky130_fd_sc_hd__a22o_1
X_1700_ _0791_ _0607_ _0610_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__a21o_1
XFILLER_0_26_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_3_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_3_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_39_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1493_ _0746_ net77 VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__and2b_1
X_1562_ _0481_ _0482_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__nor2_1
X_2045_ clknet_leaf_24_clk _0001_ VGND VGND VPWR VPWR temperature_output\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1829_ clknet_leaf_6_clk _0069_ VGND VGND VPWR VPWR data_reg\[31\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0993_ net9 VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_41_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1614_ _0711_ net2 _0520_ _0528_ _0512_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__o221a_1
X_1545_ count\[3\] _0468_ _0467_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_5_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1476_ net49 VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_37_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2028_ clknet_leaf_1_clk _0268_ VGND VGND VPWR VPWR data_reg\[7\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold250 data_reg\[24\]\[4\] VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__dlygate4sd3_1
Xhold283 data_reg\[30\]\[2\] VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__dlygate4sd3_1
Xhold261 data_reg\[12\]\[3\] VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__dlygate4sd3_1
Xhold272 data_reg\[5\]\[7\] VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1330_ _0354_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1261_ _0867_ net133 _0315_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__mux2_1
Xinput7 data_in[3] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_52_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1192_ _0852_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_54_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0976_ _0716_ _0713_ _0718_ _0722_ _0725_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__a311o_4
XTAP_TAPCELL_ROW_34_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1459_ _0422_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__clkbuf_1
X_1528_ _0458_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_48_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1313_ _0344_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_1
X_1244_ _0871_ net85 _0879_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__mux2_1
X_1175_ _0843_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0959_ address\[1\] VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__clkbuf_4
Xmax_cap25 _0821_ VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_2
XFILLER_0_33_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput10 data_in[6] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_2
X_1793_ clknet_leaf_4_clk _0041_ VGND VGND VPWR VPWR data_reg\[4\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_1862_ clknet_leaf_2_clk _0102_ VGND VGND VPWR VPWR data_reg\[17\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1931_ clknet_leaf_19_clk _0171_ VGND VGND VPWR VPWR data_reg\[22\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_1227_ net8 VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__buf_2
X_1158_ _0820_ _0831_ address\[2\] VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__nor3b_2
XFILLER_0_47_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1089_ _0730_ net220 _0792_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1012_ net66 VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
X_2061_ clknet_leaf_0_clk _0285_ VGND VGND VPWR VPWR count\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1914_ clknet_leaf_19_clk _0154_ VGND VGND VPWR VPWR data_reg\[20\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1776_ clknet_leaf_26_clk _0016_ VGND VGND VPWR VPWR data_reg\[1\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_1845_ clknet_leaf_23_clk _0085_ VGND VGND VPWR VPWR data_reg\[13\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1630_ _0495_ _0714_ data_reg\[15\]\[2\] _0790_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__a31o_1
XFILLER_0_41_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_46 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1492_ _0439_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__clkbuf_1
X_1561_ count\[7\] _0477_ count\[8\] VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_55_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2044_ clknet_leaf_26_clk _0000_ VGND VGND VPWR VPWR temperature_output\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1828_ clknet_leaf_6_clk _0068_ VGND VGND VPWR VPWR data_reg\[31\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_1759_ _0708_ _0836_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__nand2_4
XFILLER_0_50_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0992_ _0737_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__clkbuf_1
X_1613_ _0791_ _0521_ _0524_ _0527_ _0510_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__a2111o_1
X_1544_ count\[3\] count\[2\] count\[1\] count\[0\] VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__and4_1
XFILLER_0_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1475_ _0430_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__clkbuf_1
X_2027_ clknet_leaf_19_clk _0267_ VGND VGND VPWR VPWR data_reg\[8\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold273 data_reg\[29\]\[3\] VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__dlygate4sd3_1
Xhold262 data_reg\[16\]\[2\] VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_32_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold284 data_reg\[9\]\[7\] VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__dlygate4sd3_1
Xhold251 data_reg\[9\]\[0\] VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold240 data_reg\[16\]\[7\] VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput8 data_in[4] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_2
X_1260_ _0316_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1191_ _0738_ net240 _0846_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_34_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0975_ address\[2\] _0723_ _0724_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__a21oi_1
X_1527_ net10 net78 _0451_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__mux2_1
X_1458_ net9 net92 _0416_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__mux2_1
X_1389_ _0385_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_31_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1243_ _0882_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1174_ _0738_ net161 _0837_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__mux2_1
X_1312_ _0867_ net227 _0342_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0958_ _0707_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__buf_4
XFILLER_0_6_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0889_ _0670_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__buf_2
XFILLER_0_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1930_ clknet_leaf_19_clk _0170_ VGND VGND VPWR VPWR data_reg\[22\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xinput11 data_in[7] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_2
X_1792_ clknet_leaf_1_clk _0040_ VGND VGND VPWR VPWR data_reg\[4\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1861_ clknet_leaf_21_clk _0101_ VGND VGND VPWR VPWR data_reg\[17\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_1_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_1157_ address\[3\] VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__clkbuf_4
X_1226_ _0872_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1088_ _0793_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1011_ net65 pulse_duration\[3\] _0746_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2060_ clknet_leaf_0_clk net41 VGND VGND VPWR VPWR count\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1913_ clknet_leaf_15_clk _0153_ VGND VGND VPWR VPWR data_reg\[20\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1844_ clknet_leaf_24_clk _0084_ VGND VGND VPWR VPWR data_reg\[13\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_1775_ _0669_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1209_ _0861_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1560_ count\[8\] count\[7\] _0477_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__and3_1
XFILLER_0_39_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1491_ _0746_ net98 VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__and2b_1
XFILLER_0_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2043_ clknet_leaf_20_clk _0015_ VGND VGND VPWR VPWR temperature_output\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1827_ clknet_leaf_25_clk _0067_ VGND VGND VPWR VPWR pulse_duration\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1689_ _0557_ _0549_ _0600_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__and3_1
X_1758_ _0738_ _0653_ _0660_ _0514_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__o211a_1
XFILLER_0_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0991_ _0736_ net114 _0728_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1612_ _0352_ _0525_ _0526_ _0314_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__a22o_1
X_1543_ _0465_ _0467_ _0469_ _0437_ net53 VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__a32o_1
XFILLER_0_41_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1474_ net38 VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__clkbuf_1
X_2026_ clknet_leaf_19_clk _0266_ VGND VGND VPWR VPWR data_reg\[8\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold241 data_reg\[6\]\[2\] VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__dlygate4sd3_1
Xhold285 data_reg\[9\]\[3\] VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__dlygate4sd3_1
Xhold263 data_reg\[18\]\[3\] VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__dlygate4sd3_1
Xhold274 count\[11\] VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__dlygate4sd3_1
Xhold230 data_reg\[3\]\[4\] VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__dlygate4sd3_1
Xhold252 data_reg\[19\]\[1\] VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_48_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput9 data_in[5] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_59_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1190_ _0851_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0974_ address\[4\] address\[3\] VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_42_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1457_ _0421_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__clkbuf_1
X_1526_ _0457_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1388_ _0873_ net63 _0380_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2009_ clknet_leaf_23_clk _0249_ VGND VGND VPWR VPWR data_reg\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_48_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1311_ _0343_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1242_ _0869_ net170 _0879_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__mux2_1
X_1173_ _0842_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0957_ address\[4\] address\[3\] address\[2\] VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__and3b_1
X_0888_ net12 VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__clkbuf_4
X_1509_ _0448_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1860_ clknet_leaf_16_clk _0100_ VGND VGND VPWR VPWR data_reg\[17\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_26_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_26_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_26_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput12 reset_n VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1791_ clknet_leaf_23_clk _0039_ VGND VGND VPWR VPWR data_reg\[15\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_1225_ _0871_ net314 _0865_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__mux2_1
X_1087_ _0706_ net276 _0792_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__mux2_1
X_1156_ _0830_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_17_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_17_clk sky130_fd_sc_hd__clkbuf_8
X_1989_ clknet_leaf_6_clk _0229_ VGND VGND VPWR VPWR data_reg\[29\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1010_ net136 VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
X_1912_ clknet_leaf_15_clk _0152_ VGND VGND VPWR VPWR data_reg\[20\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1843_ clknet_leaf_21_clk _0083_ VGND VGND VPWR VPWR data_reg\[9\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_6_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_6_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_8_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1774_ net11 net201 _0661_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__mux2_1
X_1208_ _0738_ net238 _0855_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__mux2_1
X_1139_ address\[3\] address\[2\] _0820_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__nor3b_2
XFILLER_0_47_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1490_ _0438_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__clkbuf_1
Xhold1 net16 VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__dlygate4sd3_1
X_2042_ clknet_leaf_24_clk _0014_ VGND VGND VPWR VPWR temperature_output\[6\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_29_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1826_ clknet_leaf_26_clk _0066_ VGND VGND VPWR VPWR pulse_duration\[10\] sky130_fd_sc_hd__dfxtp_1
X_1757_ net311 _0654_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1688_ data_reg\[0\]\[4\] data_reg\[1\]\[4\] data_reg\[2\]\[4\] data_reg\[3\]\[4\]
+ _0502_ _0716_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__mux4_2
XTAP_TAPCELL_ROW_0_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0990_ net8 VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__buf_2
X_1611_ data_reg\[20\]\[1\] data_reg\[21\]\[1\] data_reg\[22\]\[1\] data_reg\[23\]\[1\]
+ _0493_ _0516_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__mux4_1
XFILLER_0_26_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1542_ _0468_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__inv_2
XFILLER_0_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1473_ _0429_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__clkbuf_1
X_2025_ clknet_leaf_14_clk _0265_ VGND VGND VPWR VPWR data_reg\[8\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold220 data_reg\[9\]\[2\] VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold242 data_reg\[22\]\[4\] VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_32_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold253 data_reg\[15\]\[3\] VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__dlygate4sd3_1
X_1809_ clknet_leaf_24_clk _0025_ VGND VGND VPWR VPWR data_reg\[2\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xhold231 data_reg\[12\]\[6\] VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__dlygate4sd3_1
Xhold286 address\[5\] VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__dlygate4sd3_1
Xhold264 data_reg\[5\]\[0\] VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__dlygate4sd3_1
Xhold275 data_reg\[19\]\[0\] VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_59_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_42_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0973_ address\[1\] address\[0\] VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__or2_2
X_1456_ net8 net303 _0416_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__mux2_1
X_1525_ net9 net74 _0451_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__mux2_1
X_1387_ _0384_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2008_ clknet_leaf_23_clk _0248_ VGND VGND VPWR VPWR data_reg\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_47_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1241_ _0881_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__clkbuf_1
X_1310_ _0864_ net249 _0342_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_56_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1172_ _0736_ net103 _0837_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0956_ net4 VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1439_ net8 net302 _0407_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__mux2_1
X_1508_ net9 net128 _0442_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_1_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput13 signal_in VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_1
X_1790_ clknet_leaf_23_clk _0038_ VGND VGND VPWR VPWR data_reg\[15\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1224_ net7 VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__buf_2
X_1086_ _0789_ _0791_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__nand2_4
X_1155_ _0742_ net76 _0822_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__mux2_1
X_1988_ clknet_leaf_5_clk _0228_ VGND VGND VPWR VPWR data_reg\[29\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_0939_ _0697_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1911_ clknet_leaf_17_clk _0151_ VGND VGND VPWR VPWR data_reg\[20\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_1842_ clknet_leaf_20_clk _0082_ VGND VGND VPWR VPWR data_reg\[9\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_1773_ _0668_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__clkbuf_1
X_1207_ _0860_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1069_ _0780_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__clkbuf_1
X_1138_ address\[4\] VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_35_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold2 net15 VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__dlygate4sd3_1
X_2041_ clknet_leaf_25_clk _0013_ VGND VGND VPWR VPWR temperature_output\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1756_ _0736_ _0653_ _0659_ _0514_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__o211a_1
XFILLER_0_44_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1825_ clknet_leaf_25_clk _0065_ VGND VGND VPWR VPWR pulse_duration\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_20_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1687_ _0557_ _0549_ _0596_ _0598_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__a31o_1
XFILLER_0_29_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1610_ data_reg\[24\]\[1\] data_reg\[25\]\[1\] data_reg\[26\]\[1\] data_reg\[27\]\[1\]
+ _0493_ _0716_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_30_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1541_ count\[2\] count\[1\] count\[0\] VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__and3_1
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1472_ net28 VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__clkbuf_1
X_2024_ clknet_leaf_11_clk _0264_ VGND VGND VPWR VPWR data_reg\[8\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold287 net18 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__dlygate4sd3_1
Xhold221 data_reg\[14\]\[2\] VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold232 data_reg\[19\]\[4\] VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__dlygate4sd3_1
Xhold254 data_reg\[18\]\[2\] VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__dlygate4sd3_1
Xhold243 data_reg\[5\]\[5\] VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__dlygate4sd3_1
Xhold265 data_reg\[20\]\[4\] VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__dlygate4sd3_1
Xhold210 data_reg\[17\]\[5\] VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__dlygate4sd3_1
Xhold276 pulse_duration\[6\] VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__dlygate4sd3_1
X_1808_ clknet_leaf_26_clk _0024_ VGND VGND VPWR VPWR data_reg\[2\]\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_20_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1739_ _0718_ _0646_ _0647_ net25 VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_59_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0972_ address\[5\] _0719_ _0720_ _0721_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_42_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1524_ _0456_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1455_ _0420_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__clkbuf_1
X_1386_ _0871_ net199 _0380_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2007_ clknet_leaf_25_clk _0247_ VGND VGND VPWR VPWR data_reg\[3\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_56_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1240_ _0867_ net83 _0879_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__mux2_1
X_1171_ _0841_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_47_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0955_ _0705_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1507_ _0447_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__clkbuf_1
X_1438_ _0411_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__clkbuf_1
X_1369_ _0871_ net222 _0371_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_53_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1223_ _0870_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__clkbuf_1
X_1154_ _0829_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1085_ address\[2\] _0790_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__nor2_8
X_1987_ clknet_leaf_8_clk _0227_ VGND VGND VPWR VPWR data_reg\[28\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_0938_ _0689_ net62 VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__and2_1
XFILLER_0_15_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1910_ clknet_leaf_15_clk _0150_ VGND VGND VPWR VPWR data_reg\[20\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1841_ clknet_leaf_10_clk _0081_ VGND VGND VPWR VPWR data_reg\[9\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1772_ net10 net195 _0661_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__mux2_1
X_1206_ _0736_ net316 _0855_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__mux2_1
X_1137_ _0819_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__clkbuf_1
X_1068_ net37 VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold3 data_reg\[0\]\[0\] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__dlygate4sd3_1
X_2040_ clknet_leaf_26_clk _0012_ VGND VGND VPWR VPWR temperature_output\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1686_ _0831_ _0549_ _0597_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__and3_1
X_1755_ _0820_ _0654_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1824_ clknet_leaf_26_clk _0064_ VGND VGND VPWR VPWR pulse_duration\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1540_ _0466_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__buf_2
XFILLER_0_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1471_ net154 VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2023_ clknet_leaf_17_clk _0263_ VGND VGND VPWR VPWR data_reg\[8\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1807_ clknet_leaf_2_clk _0055_ VGND VGND VPWR VPWR data_reg\[5\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xhold288 net14 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__dlygate4sd3_1
Xhold277 data_reg\[29\]\[4\] VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__dlygate4sd3_1
Xhold266 data_reg\[25\]\[3\] VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__dlygate4sd3_1
Xhold233 data_reg\[27\]\[1\] VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__dlygate4sd3_1
Xhold200 data_reg\[15\]\[5\] VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dlygate4sd3_1
X_1669_ _0709_ _0713_ data_reg\[19\]\[4\] VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__and3_1
Xhold244 data_reg\[17\]\[3\] VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold222 data_reg\[20\]\[6\] VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__dlygate4sd3_1
Xhold255 data_reg\[12\]\[7\] VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__dlygate4sd3_1
Xhold211 data_reg\[18\]\[1\] VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__dlygate4sd3_1
X_1738_ data_reg\[16\]\[7\] data_reg\[17\]\[7\] data_reg\[18\]\[7\] data_reg\[19\]\[7\]
+ _0502_ _0709_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__mux4_1
XFILLER_0_31_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_59_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0971_ net1 net3 VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__nand2_1
XFILLER_0_54_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1454_ net7 net259 _0416_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__mux2_1
X_1523_ net8 net178 _0451_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1385_ _0383_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_33_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2006_ clknet_leaf_26_clk _0246_ VGND VGND VPWR VPWR data_reg\[3\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1170_ _0734_ net215 _0837_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0954_ _0670_ net67 VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__and2_1
XFILLER_0_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1437_ net7 net298 _0407_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__mux2_1
X_1506_ net8 net119 _0442_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__mux2_1
X_1368_ _0374_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__clkbuf_1
X_1299_ _0871_ net132 _0333_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_53_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1084_ address\[4\] address\[3\] VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__or2b_2
X_1222_ _0869_ net315 _0865_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__mux2_1
X_1153_ _0740_ net111 _0822_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__mux2_1
X_1986_ clknet_leaf_7_clk _0226_ VGND VGND VPWR VPWR data_reg\[28\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_50_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_9_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_9_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_30_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0937_ _0696_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1840_ clknet_leaf_10_clk _0080_ VGND VGND VPWR VPWR data_reg\[9\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1771_ _0667_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1067_ _0779_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__clkbuf_1
X_1205_ _0859_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__clkbuf_1
X_1136_ _0742_ net280 _0811_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__mux2_1
X_1969_ clknet_leaf_10_clk _0209_ VGND VGND VPWR VPWR data_reg\[10\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold4 net19 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_17_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1823_ clknet_leaf_0_clk _0063_ VGND VGND VPWR VPWR pulse_duration\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1754_ _0734_ _0653_ _0658_ _0514_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__o211a_1
X_1685_ data_reg\[12\]\[4\] data_reg\[13\]\[4\] data_reg\[14\]\[4\] data_reg\[15\]\[4\]
+ _0502_ _0709_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__mux4_1
XFILLER_0_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1119_ _0809_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1470_ net153 pulse_duration\[11\] _0745_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2022_ clknet_leaf_12_clk _0262_ VGND VGND VPWR VPWR data_reg\[8\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold201 pulse_duration\[3\] VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_17_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1806_ clknet_leaf_2_clk _0054_ VGND VGND VPWR VPWR data_reg\[5\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_1668_ net312 _0490_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__and2_1
Xhold267 data_reg\[29\]\[6\] VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__dlygate4sd3_1
X_1599_ _0491_ _0513_ _0514_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__o21a_1
Xhold278 data_reg\[30\]\[4\] VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__dlygate4sd3_1
Xhold245 data_reg\[28\]\[3\] VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__dlygate4sd3_1
Xhold234 data_reg\[30\]\[3\] VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__dlygate4sd3_1
Xhold223 data_reg\[28\]\[5\] VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__dlygate4sd3_1
X_1737_ data_reg\[28\]\[7\] data_reg\[29\]\[7\] data_reg\[30\]\[7\] data_reg\[31\]\[7\]
+ _0712_ _0531_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__mux4_1
Xhold256 data_reg\[4\]\[1\] VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__dlygate4sd3_1
Xhold212 data_reg\[4\]\[5\] VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__dlygate4sd3_1
Xhold289 data_reg\[19\]\[3\] VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_59_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0970_ net2 VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__inv_2
X_1453_ _0419_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__clkbuf_1
X_1522_ _0455_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__clkbuf_1
X_1384_ _0869_ net205 _0380_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__mux2_1
X_2005_ clknet_leaf_25_clk _0245_ VGND VGND VPWR VPWR data_reg\[3\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_33_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0953_ _0704_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1436_ _0410_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__clkbuf_1
X_1367_ _0869_ net125 _0371_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__mux2_1
X_1505_ _0446_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_53_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_43_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1298_ _0336_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_52_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1221_ net6 VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__buf_2
X_1083_ _0788_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__buf_4
X_1152_ _0828_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__clkbuf_1
X_1985_ clknet_leaf_7_clk _0225_ VGND VGND VPWR VPWR data_reg\[28\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_50_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0936_ _0689_ net102 VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1419_ _0401_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_5_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1770_ net9 net185 _0661_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1204_ _0734_ net288 _0855_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__mux2_1
X_1066_ net30 VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__clkbuf_1
X_1135_ _0818_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__clkbuf_1
X_1968_ clknet_leaf_10_clk _0208_ VGND VGND VPWR VPWR data_reg\[10\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_50_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0919_ _0679_ net45 VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__and2_1
X_1899_ clknet_leaf_22_clk _0139_ VGND VGND VPWR VPWR data_reg\[19\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_26_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold5 data_reg\[31\]\[1\] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1753_ _0557_ _0653_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1822_ clknet_leaf_4_clk _0062_ VGND VGND VPWR VPWR pulse_duration\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1684_ data_reg\[4\]\[4\] data_reg\[5\]\[4\] data_reg\[6\]\[4\] data_reg\[7\]\[4\]
+ _0494_ _0495_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__mux4_1
XFILLER_0_29_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1049_ _0770_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__clkbuf_1
X_1118_ _0742_ net118 _0801_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2021_ clknet_leaf_14_clk _0261_ VGND VGND VPWR VPWR data_reg\[8\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_57_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold235 data_reg\[22\]\[2\] VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__dlygate4sd3_1
X_1805_ clknet_leaf_3_clk _0053_ VGND VGND VPWR VPWR data_reg\[5\]\[5\] sky130_fd_sc_hd__dfxtp_1
Xhold224 data_reg\[23\]\[0\] VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__dlygate4sd3_1
Xhold213 data_reg\[18\]\[5\] VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_17_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1736_ _0352_ _0643_ _0644_ _0832_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__a22o_1
Xhold202 data_reg\[23\]\[1\] VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_25_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1667_ net32 _0512_ _0568_ _0579_ _0514_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__o221a_1
Xhold246 data_reg\[30\]\[7\] VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__dlygate4sd3_1
Xhold279 data_reg\[29\]\[2\] VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__dlygate4sd3_1
X_1598_ _0670_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__clkbuf_4
Xhold268 data_reg\[21\]\[2\] VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__dlygate4sd3_1
Xhold257 data_reg\[15\]\[0\] VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_56_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_34_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1452_ net6 net308 _0416_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__mux2_1
X_1521_ net7 net241 _0451_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__mux2_1
X_1383_ _0382_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__clkbuf_1
X_2004_ clknet_leaf_26_clk _0244_ VGND VGND VPWR VPWR data_reg\[3\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_26_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1719_ data_reg\[4\]\[6\] data_reg\[5\]\[6\] data_reg\[6\]\[6\] data_reg\[7\]\[6\]
+ _0502_ _0709_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_56_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0952_ _0670_ net45 VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__and2_1
X_1504_ net7 net168 _0442_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1435_ net6 net304 _0407_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__mux2_1
X_1366_ _0373_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_53_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1297_ _0869_ net260 _0333_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1151_ _0738_ net235 _0822_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_9_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1220_ _0868_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__clkbuf_1
X_1082_ _0726_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__and2b_1
X_1984_ clknet_leaf_7_clk _0224_ VGND VGND VPWR VPWR data_reg\[28\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_0935_ _0695_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_21_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1418_ net6 net273 _0398_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1349_ _0364_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1203_ _0858_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__clkbuf_1
X_1134_ _0740_ net256 _0811_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__mux2_1
X_1065_ _0778_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1898_ clknet_leaf_22_clk _0138_ VGND VGND VPWR VPWR data_reg\[19\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_1967_ clknet_leaf_16_clk _0207_ VGND VGND VPWR VPWR data_reg\[10\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_0918_ _0686_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
Xhold6 data_reg\[31\]\[3\] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_29_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1683_ _0831_ _0590_ _0593_ _0594_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__a31o_1
Xclkbuf_leaf_10_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_10_clk sky130_fd_sc_hd__clkbuf_8
X_1752_ _0732_ _0653_ _0657_ _0514_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__o211a_1
X_1821_ clknet_leaf_4_clk _0061_ VGND VGND VPWR VPWR pulse_duration\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_20_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1117_ _0808_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__clkbuf_1
X_1048_ net143 count\[4\] _0754_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_1_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_1_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_14_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2020_ clknet_leaf_19_clk _0260_ VGND VGND VPWR VPWR data_reg\[8\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold269 data_reg\[5\]\[4\] VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__dlygate4sd3_1
X_1804_ clknet_leaf_7_clk _0052_ VGND VGND VPWR VPWR data_reg\[5\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1666_ _0557_ _0571_ _0574_ _0578_ _0490_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__a311o_1
Xhold203 data_reg\[14\]\[4\] VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dlygate4sd3_1
Xhold225 data_reg\[12\]\[2\] VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold247 data_reg\[17\]\[0\] VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__dlygate4sd3_1
Xhold214 data_reg\[9\]\[6\] VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1735_ data_reg\[4\]\[7\] data_reg\[5\]\[7\] data_reg\[6\]\[7\] data_reg\[7\]\[7\]
+ _0502_ _0709_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__mux4_1
Xhold236 data_reg\[5\]\[6\] VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__dlygate4sd3_1
Xhold258 data_reg\[18\]\[6\] VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_56_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1597_ _0714_ net2 _0499_ _0511_ _0512_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__o221a_1
XFILLER_0_48_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1520_ _0454_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_22_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1451_ _0418_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__clkbuf_1
X_1382_ _0867_ net182 _0380_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__mux2_1
X_2003_ clknet_leaf_8_clk _0243_ VGND VGND VPWR VPWR data_reg\[30\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1649_ data_reg\[29\]\[3\] _0787_ _0834_ data_reg\[30\]\[3\] _0561_ VGND VGND VPWR
+ VPWR _0562_ sky130_fd_sc_hd__a221o_1
XFILLER_0_13_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1718_ data_reg\[24\]\[6\] data_reg\[25\]\[6\] data_reg\[26\]\[6\] data_reg\[27\]\[6\]
+ _0712_ _0531_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_56_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0951_ _0703_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
X_1503_ _0445_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1434_ _0409_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__clkbuf_1
X_1365_ _0867_ net107 _0371_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__mux2_1
X_1296_ _0335_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1150_ _0827_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_9_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1081_ _0786_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__clkbuf_4
X_1983_ clknet_leaf_8_clk _0223_ VGND VGND VPWR VPWR data_reg\[28\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0934_ _0689_ net56 VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__and2_1
X_1417_ _0400_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1348_ _0867_ net142 _0362_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__mux2_1
X_1279_ _0326_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_6_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1064_ net33 VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__clkbuf_1
X_1133_ _0817_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__clkbuf_1
X_1202_ _0732_ net279 _0855_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__mux2_1
X_1966_ clknet_leaf_12_clk _0206_ VGND VGND VPWR VPWR data_reg\[10\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1897_ clknet_leaf_16_clk _0137_ VGND VGND VPWR VPWR data_reg\[19\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_0917_ _0679_ net88 VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_49_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold7 net17 VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__dlygate4sd3_1
X_1820_ clknet_leaf_5_clk _0060_ VGND VGND VPWR VPWR pulse_duration\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_25_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1682_ _0550_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__inv_2
XFILLER_0_52_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1751_ _0548_ _0653_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__nand2_1
X_1047_ _0769_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1116_ _0740_ net113 _0801_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__mux2_1
X_1949_ clknet_leaf_14_clk _0189_ VGND VGND VPWR VPWR data_reg\[25\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1803_ clknet_leaf_5_clk _0051_ VGND VGND VPWR VPWR data_reg\[5\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1596_ net3 net1 VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__nor2b_2
Xhold248 data_reg\[28\]\[2\] VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__dlygate4sd3_1
Xhold237 data_reg\[9\]\[5\] VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__dlygate4sd3_1
Xhold259 data_reg\[7\]\[1\] VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__dlygate4sd3_1
X_1665_ _0756_ _0575_ _0577_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__o21a_1
Xhold226 data_reg\[12\]\[4\] VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__dlygate4sd3_1
Xhold215 data_reg\[16\]\[5\] VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__dlygate4sd3_1
Xhold204 data_reg\[22\]\[6\] VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__dlygate4sd3_1
X_1734_ data_reg\[24\]\[7\] data_reg\[25\]\[7\] data_reg\[26\]\[7\] data_reg\[27\]\[7\]
+ _0712_ _0531_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2079_ clknet_leaf_23_clk _0303_ VGND VGND VPWR VPWR data_reg\[14\]\[0\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1450_ net5 net75 _0416_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__mux2_1
X_1381_ _0381_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__clkbuf_1
X_2002_ clknet_leaf_7_clk _0242_ VGND VGND VPWR VPWR data_reg\[30\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1648_ _0710_ _0714_ data_reg\[31\]\[3\] VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__and3_1
XFILLER_0_6_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1717_ _0791_ _0625_ _0626_ net22 VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__a22o_1
X_1579_ _0716_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__buf_4
XFILLER_0_8_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0950_ _0670_ net88 VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__and2_1
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1433_ net5 net71 _0407_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__mux2_1
X_1502_ net6 net99 _0442_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__mux2_1
X_1364_ _0372_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1295_ _0867_ net219 _0333_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_52_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1080_ address\[1\] _0712_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__and2b_1
XFILLER_0_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1982_ clknet_leaf_8_clk _0222_ VGND VGND VPWR VPWR data_reg\[28\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0933_ _0694_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
X_1416_ net5 net108 _0398_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1347_ _0363_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1278_ _0867_ net80 _0324_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_6_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1201_ _0857_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__clkbuf_1
X_1132_ _0738_ net242 _0811_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__mux2_1
XFILLER_0_34_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1063_ net264 VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1965_ clknet_leaf_16_clk _0205_ VGND VGND VPWR VPWR data_reg\[10\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_0916_ _0685_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__clkbuf_1
X_1896_ clknet_leaf_16_clk _0136_ VGND VGND VPWR VPWR data_reg\[19\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold8 data_reg\[31\]\[0\] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__dlygate4sd3_1
X_1750_ _0730_ _0653_ _0656_ _0514_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_25_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1681_ data_reg\[29\]\[4\] _0787_ _0592_ _0548_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__a211o_1
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1046_ net226 net46 _0754_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__mux2_1
X_1115_ _0807_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1948_ clknet_leaf_13_clk _0188_ VGND VGND VPWR VPWR data_reg\[25\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1879_ clknet_leaf_22_clk _0119_ VGND VGND VPWR VPWR data_reg\[16\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1802_ clknet_leaf_9_clk _0050_ VGND VGND VPWR VPWR data_reg\[5\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_45_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1733_ _0791_ _0640_ _0641_ net22 VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__a22o_1
Xhold227 data_reg\[26\]\[4\] VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__dlygate4sd3_1
Xhold216 data_reg\[7\]\[3\] VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__dlygate4sd3_1
X_1664_ _0548_ _0576_ _0790_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__o21ba_1
Xhold249 data_reg\[14\]\[3\] VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__dlygate4sd3_1
X_1595_ net25 _0500_ _0505_ _0509_ _0510_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_0_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold238 pulse_duration\[11\] VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__dlygate4sd3_1
Xhold205 data_reg\[16\]\[0\] VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1029_ _0760_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
X_2078_ clknet_leaf_10_clk _0302_ VGND VGND VPWR VPWR address\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1380_ _0864_ net91 _0380_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__mux2_1
X_2001_ clknet_leaf_6_clk _0241_ VGND VGND VPWR VPWR data_reg\[30\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_1716_ data_reg\[0\]\[6\] data_reg\[1\]\[6\] data_reg\[2\]\[6\] data_reg\[3\]\[6\]
+ _0712_ _0531_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__mux4_1
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1647_ net26 _0512_ _0560_ _0514_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__o211a_1
X_1578_ _0493_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_38_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1432_ _0408_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__clkbuf_1
X_1363_ _0864_ net190 _0371_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__mux2_1
X_1501_ _0444_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1294_ _0334_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_52_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1981_ clknet_leaf_5_clk _0221_ VGND VGND VPWR VPWR data_reg\[28\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_0932_ _0689_ net70 VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__and2_1
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1415_ _0399_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__clkbuf_1
X_1346_ _0864_ net122 _0362_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__mux2_1
X_1277_ _0325_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_22_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_22_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_20_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1200_ _0730_ net236 _0855_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__mux2_1
X_1131_ _0816_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__clkbuf_1
X_1062_ net263 count\[11\] _0745_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_25_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_13_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_13_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1895_ clknet_leaf_16_clk _0135_ VGND VGND VPWR VPWR data_reg\[19\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_1964_ clknet_leaf_21_clk _0204_ VGND VGND VPWR VPWR data_reg\[10\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_0915_ _0679_ net68 VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__and2_1
X_1329_ _0864_ net210 _0353_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold9 data_reg\[0\]\[4\] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_29_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1680_ data_reg\[28\]\[4\] _0532_ _0834_ data_reg\[30\]\[4\] _0591_ VGND VGND VPWR
+ VPWR _0592_ sky130_fd_sc_hd__a221o_1
X_1114_ _0738_ net174 _0801_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_2_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_2_clk sky130_fd_sc_hd__clkbuf_8
X_1045_ _0768_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1878_ clknet_leaf_16_clk _0118_ VGND VGND VPWR VPWR data_reg\[16\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1947_ clknet_leaf_18_clk _0187_ VGND VGND VPWR VPWR data_reg\[24\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_39_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1801_ clknet_leaf_3_clk _0049_ VGND VGND VPWR VPWR data_reg\[5\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xhold217 data_reg\[12\]\[5\] VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__dlygate4sd3_1
Xhold206 pulse_duration\[5\] VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__dlygate4sd3_1
X_1663_ data_reg\[12\]\[3\] data_reg\[13\]\[3\] data_reg\[14\]\[3\] data_reg\[15\]\[3\]
+ _0503_ _0710_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__mux4_1
X_1732_ data_reg\[0\]\[7\] data_reg\[1\]\[7\] data_reg\[2\]\[7\] data_reg\[3\]\[7\]
+ _0712_ _0531_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__mux4_1
XFILLER_0_13_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1594_ net3 net2 VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__or2b_2
XFILLER_0_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold239 _0777_ VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__dlygate4sd3_1
Xhold228 data_reg\[6\]\[7\] VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__dlygate4sd3_1
X_2077_ clknet_leaf_9_clk _0301_ VGND VGND VPWR VPWR address\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_36_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1028_ _0732_ net166 _0757_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_12_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_58_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2000_ clknet_leaf_7_clk _0240_ VGND VGND VPWR VPWR data_reg\[30\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_26_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1646_ _0756_ _0547_ _0559_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1715_ data_reg\[8\]\[6\] data_reg\[9\]\[6\] data_reg\[10\]\[6\] data_reg\[11\]\[6\]
+ address\[0\] _0531_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__mux4_1
X_1577_ address\[0\] VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__buf_6
XFILLER_0_6_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1500_ net5 net202 _0442_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1431_ net4 net203 _0407_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__mux2_1
X_1293_ _0864_ net214 _0333_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__mux2_1
X_1362_ _0836_ _0352_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__nand2_4
XFILLER_0_41_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1629_ _0831_ _0540_ _0542_ _0820_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__or4b_1
XTAP_TAPCELL_ROW_52_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1980_ clknet_leaf_5_clk _0220_ VGND VGND VPWR VPWR data_reg\[28\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_0931_ _0693_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
X_1414_ net4 net123 _0398_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__mux2_1
X_1276_ _0864_ net197 _0324_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__mux2_1
X_1345_ _0789_ _0352_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__nand2_4
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire23 _0832_ VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_2
XFILLER_0_46_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_6_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1130_ _0736_ net251 _0811_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_0_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1061_ _0776_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1894_ clknet_leaf_16_clk _0134_ VGND VGND VPWR VPWR data_reg\[19\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_0914_ _0684_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
X_1963_ clknet_leaf_18_clk _0203_ VGND VGND VPWR VPWR data_reg\[26\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1259_ _0864_ net189 _0315_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__mux2_1
X_1328_ _0810_ _0352_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__nand2_4
XFILLER_0_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_3_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1044_ net135 net53 _0754_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__mux2_1
X_1113_ _0806_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1877_ clknet_leaf_21_clk _0117_ VGND VGND VPWR VPWR data_reg\[16\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_1946_ clknet_leaf_17_clk _0186_ VGND VGND VPWR VPWR data_reg\[24\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1800_ clknet_leaf_2_clk _0048_ VGND VGND VPWR VPWR data_reg\[5\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold218 data_reg\[29\]\[7\] VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__dlygate4sd3_1
Xhold207 data_reg\[24\]\[3\] VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1662_ data_reg\[8\]\[3\] data_reg\[9\]\[3\] data_reg\[10\]\[3\] data_reg\[11\]\[3\]
+ _0714_ _0711_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__mux4_1
X_1731_ data_reg\[8\]\[7\] data_reg\[9\]\[7\] data_reg\[10\]\[7\] data_reg\[11\]\[7\]
+ address\[0\] _0531_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__mux4_1
Xhold229 data_reg\[16\]\[6\] VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__dlygate4sd3_1
X_1593_ net23 _0506_ _0507_ _0508_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2076_ clknet_leaf_9_clk _0300_ VGND VGND VPWR VPWR address\[3\] sky130_fd_sc_hd__dfxtp_1
X_1027_ _0759_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_36_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1929_ clknet_leaf_15_clk _0169_ VGND VGND VPWR VPWR data_reg\[22\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold90 data_reg\[13\]\[1\] VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1645_ _0548_ _0554_ _0558_ _0490_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__a31o_1
X_1576_ data_reg\[24\]\[0\] data_reg\[25\]\[0\] data_reg\[26\]\[0\] data_reg\[27\]\[0\]
+ _0714_ _0711_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__mux4_1
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1714_ _0314_ _0622_ _0623_ _0708_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__a22o_1
XFILLER_0_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2059_ clknet_leaf_0_clk _0283_ VGND VGND VPWR VPWR count\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1430_ _0718_ _0789_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__nand2_4
X_1292_ _0836_ _0314_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__nand2_4
XFILLER_0_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1361_ _0370_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1628_ data_reg\[21\]\[2\] _0786_ _0833_ data_reg\[22\]\[2\] _0541_ VGND VGND VPWR
+ VPWR _0542_ sky130_fd_sc_hd__a221o_1
X_1559_ _0467_ _0479_ _0480_ _0437_ net89 VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_52_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0930_ _0689_ net104 VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1413_ _0718_ _0810_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__nand2_4
X_1275_ _0789_ _0314_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__nand2_4
X_1344_ _0361_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_6_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1060_ net116 net51 _0745_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1962_ clknet_leaf_17_clk _0202_ VGND VGND VPWR VPWR data_reg\[26\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0913_ _0679_ net163 VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__and2_1
X_1893_ clknet_leaf_17_clk _0133_ VGND VGND VPWR VPWR data_reg\[19\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_1327_ _0351_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__buf_4
X_1258_ _0810_ _0314_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__nand2_4
X_1189_ _0736_ net305 _0846_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_3_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1112_ _0736_ net95 _0801_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__mux2_1
X_1043_ _0767_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__clkbuf_1
X_1945_ clknet_leaf_13_clk _0185_ VGND VGND VPWR VPWR data_reg\[24\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1876_ clknet_leaf_21_clk _0116_ VGND VGND VPWR VPWR data_reg\[16\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold208 data_reg\[28\]\[6\] VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__dlygate4sd3_1
X_1661_ _0552_ _0572_ _0573_ _0550_ _0548_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__a221o_1
XFILLER_0_40_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold219 data_reg\[7\]\[7\] VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__dlygate4sd3_1
X_1730_ _0314_ _0637_ _0638_ _0708_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__a22o_1
X_1592_ data_reg\[0\]\[0\] data_reg\[1\]\[0\] data_reg\[2\]\[0\] data_reg\[3\]\[0\]
+ _0503_ _0710_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__mux4_1
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_46_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2075_ clknet_leaf_9_clk _0299_ VGND VGND VPWR VPWR address\[2\] sky130_fd_sc_hd__dfxtp_4
X_1026_ _0730_ net112 _0757_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1928_ clknet_leaf_15_clk _0168_ VGND VGND VPWR VPWR data_reg\[22\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1859_ clknet_leaf_20_clk _0099_ VGND VGND VPWR VPWR data_reg\[12\]\[7\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_55_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_33_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold80 data_reg\[3\]\[7\] VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dlygate4sd3_1
Xhold91 pulse_duration\[10\] VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1713_ data_reg\[12\]\[6\] data_reg\[13\]\[6\] data_reg\[14\]\[6\] data_reg\[15\]\[6\]
+ _0712_ _0531_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__mux4_1
X_1575_ net313 _0490_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__and2_1
X_1644_ _0552_ _0555_ _0556_ _0550_ _0557_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__a221o_1
X_1009_ data_reg\[4\]\[2\] net135 _0746_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__mux2_1
X_2058_ clknet_leaf_4_clk _0282_ VGND VGND VPWR VPWR count\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_55_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1360_ _0311_ net86 _0362_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__mux2_1
X_1291_ _0332_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1627_ address\[1\] _0493_ data_reg\[23\]\[2\] VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__and3_1
X_1489_ _0437_ net255 VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__and2b_1
X_1558_ net89 _0477_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_52_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_25_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_25_clk sky130_fd_sc_hd__clkbuf_8
X_1343_ _0311_ net134 _0353_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__mux2_1
X_1412_ _0397_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1274_ _0323_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_16_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_16_clk sky130_fd_sc_hd__clkbuf_8
X_0989_ _0735_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1961_ clknet_leaf_12_clk _0201_ VGND VGND VPWR VPWR data_reg\[26\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1892_ clknet_leaf_16_clk _0132_ VGND VGND VPWR VPWR data_reg\[19\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_0912_ _0683_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_5_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_5_clk sky130_fd_sc_hd__clkbuf_8
X_1326_ address\[2\] address\[3\] address\[4\] VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__and3b_1
X_1257_ _0313_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__clkbuf_8
X_1188_ _0850_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1042_ net217 count\[1\] _0754_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__mux2_1
X_1111_ _0805_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__clkbuf_1
X_1944_ clknet_leaf_11_clk _0184_ VGND VGND VPWR VPWR data_reg\[24\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1875_ clknet_leaf_2_clk _0115_ VGND VGND VPWR VPWR data_reg\[6\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1309_ _0727_ _0314_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__nand2_4
XFILLER_0_57_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold209 data_reg\[6\]\[1\] VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__dlygate4sd3_1
X_1591_ _0820_ _0831_ _0756_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__nor3_2
X_1660_ data_reg\[20\]\[3\] data_reg\[21\]\[3\] data_reg\[22\]\[3\] data_reg\[23\]\[3\]
+ _0714_ _0711_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__mux4_2
XFILLER_0_56_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2074_ clknet_leaf_16_clk _0298_ VGND VGND VPWR VPWR address\[1\] sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_36_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1025_ _0758_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1927_ clknet_leaf_17_clk _0167_ VGND VGND VPWR VPWR data_reg\[22\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1858_ clknet_leaf_21_clk _0098_ VGND VGND VPWR VPWR data_reg\[12\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_1789_ clknet_leaf_2_clk _0037_ VGND VGND VPWR VPWR data_reg\[15\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold70 data_reg\[13\]\[4\] VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dlygate4sd3_1
Xhold81 data_reg\[21\]\[7\] VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dlygate4sd3_1
Xhold92 data_reg\[14\]\[1\] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_33_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_1 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1643_ _0831_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__inv_2
XFILLER_0_5_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1712_ data_reg\[20\]\[6\] data_reg\[21\]\[6\] data_reg\[22\]\[6\] data_reg\[23\]\[6\]
+ address\[0\] address\[1\] VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__mux4_1
X_1574_ net3 net1 VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__nand2b_4
XFILLER_0_6_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2057_ clknet_leaf_4_clk _0281_ VGND VGND VPWR VPWR count\[5\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_16_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1008_ _0748_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_30_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1290_ _0311_ net106 _0324_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1626_ data_reg\[20\]\[2\] _0532_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__and2_1
X_1557_ count\[7\] _0477_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__or2_1
X_1488_ _0745_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_52_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1273_ _0311_ net151 _0315_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__mux2_1
X_1411_ _0311_ net159 _0389_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__mux2_1
X_1342_ _0360_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0988_ _0734_ net278 _0728_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__mux2_1
X_1609_ net23 _0522_ _0523_ _0718_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1960_ clknet_leaf_11_clk _0200_ VGND VGND VPWR VPWR data_reg\[26\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_50_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0911_ _0679_ net155 VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__and2_1
X_1891_ clknet_leaf_22_clk _0131_ VGND VGND VPWR VPWR data_reg\[18\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_11_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1256_ address\[3\] address\[2\] address\[4\] VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__and3b_1
X_1325_ _0350_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__clkbuf_1
X_1187_ _0734_ net120 _0846_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_4_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1110_ _0734_ net224 _0801_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__mux2_1
X_1041_ _0766_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1943_ clknet_leaf_12_clk _0183_ VGND VGND VPWR VPWR data_reg\[24\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1874_ clknet_leaf_1_clk _0114_ VGND VGND VPWR VPWR data_reg\[6\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1308_ _0341_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__clkbuf_1
X_1239_ _0880_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1590_ data_reg\[4\]\[0\] data_reg\[5\]\[0\] data_reg\[6\]\[0\] data_reg\[7\]\[0\]
+ _0503_ _0710_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__mux4_1
XFILLER_0_0_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2073_ clknet_leaf_10_clk _0297_ VGND VGND VPWR VPWR address\[0\] sky130_fd_sc_hd__dfxtp_4
X_1024_ _0706_ net289 _0757_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_44_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1788_ clknet_leaf_3_clk _0036_ VGND VGND VPWR VPWR data_reg\[15\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1926_ clknet_leaf_14_clk _0166_ VGND VGND VPWR VPWR data_reg\[22\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_1857_ clknet_leaf_2_clk _0097_ VGND VGND VPWR VPWR data_reg\[12\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold82 data_reg\[26\]\[1\] VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dlygate4sd3_1
Xhold71 data_reg\[7\]\[0\] VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dlygate4sd3_1
Xhold60 data_reg\[11\]\[3\] VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dlygate4sd3_1
Xhold93 data_reg\[13\]\[7\] VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_33_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_2 _0713_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1642_ data_reg\[24\]\[2\] data_reg\[25\]\[2\] data_reg\[26\]\[2\] data_reg\[27\]\[2\]
+ _0494_ _0495_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__mux4_1
X_1711_ _0719_ _0621_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1573_ net13 _0719_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__nor2_1
X_1007_ net281 net217 _0746_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__mux2_1
X_2056_ clknet_leaf_4_clk _0280_ VGND VGND VPWR VPWR count\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1909_ clknet_leaf_18_clk _0149_ VGND VGND VPWR VPWR data_reg\[20\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_50_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1625_ data_reg\[4\]\[2\] _0532_ _0724_ _0538_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__a211o_1
XFILLER_0_41_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1556_ _0477_ _0478_ net50 _0437_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_26_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1487_ _0436_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2039_ clknet_leaf_25_clk _0011_ VGND VGND VPWR VPWR temperature_output\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1410_ _0396_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1272_ _0322_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__clkbuf_1
X_1341_ _0886_ net175 _0353_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__mux2_1
X_0987_ net7 VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_13_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1608_ data_reg\[28\]\[1\] data_reg\[29\]\[1\] data_reg\[30\]\[1\] data_reg\[31\]\[1\]
+ _0493_ _0516_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__mux4_2
X_1539_ net12 _0461_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold190 data_reg\[6\]\[3\] VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0910_ _0682_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1890_ clknet_leaf_2_clk _0130_ VGND VGND VPWR VPWR data_reg\[18\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_11_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1186_ _0849_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__clkbuf_1
X_1255_ _0312_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__clkbuf_1
X_1324_ _0311_ net162 _0342_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1040_ net57 count\[0\] _0754_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__mux2_1
X_1942_ clknet_leaf_13_clk _0182_ VGND VGND VPWR VPWR data_reg\[24\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1873_ clknet_leaf_3_clk _0113_ VGND VGND VPWR VPWR data_reg\[6\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1169_ _0840_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1307_ _0311_ net141 _0333_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__mux2_1
X_1238_ _0864_ net147 _0879_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2072_ clknet_leaf_11_clk _0296_ VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__dfxtp_1
X_1023_ _0756_ _0711_ _0724_ _0726_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__a211o_4
XTAP_TAPCELL_ROW_36_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1925_ clknet_leaf_18_clk _0165_ VGND VGND VPWR VPWR data_reg\[22\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_1856_ clknet_leaf_3_clk _0096_ VGND VGND VPWR VPWR data_reg\[12\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1787_ clknet_leaf_2_clk _0035_ VGND VGND VPWR VPWR data_reg\[15\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_42_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold72 data_reg\[29\]\[5\] VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dlygate4sd3_1
Xhold50 data_reg\[30\]\[1\] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dlygate4sd3_1
Xhold83 data_reg\[28\]\[1\] VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dlygate4sd3_1
Xhold94 data_reg\[8\]\[4\] VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 data_reg\[25\]\[7\] VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_51_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_60_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1641_ data_reg\[8\]\[2\] data_reg\[9\]\[2\] data_reg\[10\]\[2\] data_reg\[11\]\[2\]
+ _0503_ _0710_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__mux4_1
X_1710_ net29 _0490_ _0620_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1572_ _0488_ _0460_ _0486_ _0489_ _0671_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__o311a_1
X_2055_ clknet_leaf_4_clk _0279_ VGND VGND VPWR VPWR count\[3\] sky130_fd_sc_hd__dfxtp_1
X_1006_ net58 VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__clkbuf_1
X_1908_ clknet_leaf_14_clk _0148_ VGND VGND VPWR VPWR data_reg\[20\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_1839_ clknet_leaf_16_clk _0079_ VGND VGND VPWR VPWR data_reg\[9\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1624_ data_reg\[5\]\[2\] _0787_ _0834_ data_reg\[6\]\[2\] _0537_ VGND VGND VPWR
+ VPWR _0538_ sky130_fd_sc_hd__a221o_1
X_1555_ count\[6\] _0474_ _0467_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__o21ai_1
X_1486_ net35 VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_19_clk clknet_1_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_19_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2038_ clknet_leaf_25_clk _0010_ VGND VGND VPWR VPWR temperature_output\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1340_ _0359_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1271_ _0886_ net247 _0315_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_8_clk clknet_1_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_8_clk sky130_fd_sc_hd__clkbuf_8
X_0986_ _0733_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1607_ data_reg\[4\]\[1\] data_reg\[5\]\[1\] data_reg\[6\]\[1\] data_reg\[7\]\[1\]
+ _0502_ _0716_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__mux4_1
X_1538_ count\[1\] count\[0\] count\[2\] VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__a21o_1
X_1469_ _0427_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_38_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold180 data_reg\[10\]\[2\] VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold191 data_reg\[3\]\[1\] VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1323_ _0349_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__clkbuf_1
X_1185_ _0732_ net287 _0846_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__mux2_1
X_1254_ _0311_ net167 _0879_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0969_ net12 VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__inv_2
XFILLER_0_6_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1872_ clknet_leaf_5_clk _0112_ VGND VGND VPWR VPWR data_reg\[6\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1941_ clknet_leaf_14_clk _0181_ VGND VGND VPWR VPWR data_reg\[24\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1306_ _0340_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__clkbuf_1
X_1168_ _0732_ net266 _0837_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__mux2_1
X_1237_ _0727_ _0791_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__nand2_4
X_1099_ _0740_ net239 _0792_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2071_ clknet_leaf_11_clk _0295_ VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__dfxtp_1
X_1022_ address\[2\] VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_44_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1924_ clknet_leaf_14_clk _0164_ VGND VGND VPWR VPWR data_reg\[22\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_1855_ clknet_leaf_2_clk _0095_ VGND VGND VPWR VPWR data_reg\[12\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1786_ clknet_leaf_9_clk _0034_ VGND VGND VPWR VPWR data_reg\[15\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold40 data_reg\[4\]\[3\] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold62 data_reg\[11\]\[4\] VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_42_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold95 data_reg\[16\]\[3\] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dlygate4sd3_1
Xhold84 pulse_duration\[9\] VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dlygate4sd3_1
Xhold73 data_reg\[3\]\[5\] VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 data_reg\[17\]\[7\] VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1640_ _0550_ _0551_ _0552_ _0553_ _0831_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__a221o_1
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1571_ net51 _0461_ _0484_ net299 VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__a31o_1
X_2054_ clknet_leaf_4_clk net54 VGND VGND VPWR VPWR count\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_32_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1005_ data_reg\[4\]\[0\] net57 _0746_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__mux2_1
X_1838_ clknet_leaf_10_clk _0078_ VGND VGND VPWR VPWR data_reg\[9\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1907_ clknet_leaf_19_clk _0147_ VGND VGND VPWR VPWR data_reg\[11\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_1769_ _0666_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1623_ _0716_ _0503_ data_reg\[7\]\[2\] VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__and3_1
X_1554_ count\[6\] count\[5\] count\[4\] _0470_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__and4_1
X_1485_ _0435_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__clkbuf_1
.ends
