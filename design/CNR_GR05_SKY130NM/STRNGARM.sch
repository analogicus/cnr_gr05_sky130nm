v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -450 -340 -430 -340 {
lab=VPOUT}
N -360 -340 -340 -340 {
lab=VPOUT}
N -490 -310 -490 -270 {
lab=#net1}
N -300 -310 -300 -270 {
lab=#net2}
N -490 -210 -300 -210 {
lab=#net3}
N -390 -210 -390 -180 {
lab=#net3}
N -390 -120 -390 -60 {
lab=VSS}
N -620 -60 -390 -60 {
lab=VSS}
N -430 -340 -330 -390 {
lab=VPOUT}
N -330 -390 -300 -390 {
lab=VPOUT}
N -460 -390 -360 -340 {
lab=VPOUT}
N -490 -390 -460 -390 {
lab=VPOUT}
N -490 -440 -490 -370 {
lab=VPOUT}
N -300 -440 -300 -370 {
lab=VPOUT}
N -450 -470 -430 -470 {
lab=VPOUT}
N -430 -470 -330 -420 {
lab=VPOUT}
N -330 -420 -300 -420 {
lab=VPOUT}
N -360 -470 -340 -470 {
lab=VPOUT}
N -460 -420 -360 -470 {
lab=VPOUT}
N -490 -420 -460 -420 {
lab=VPOUT}
N -490 -540 -490 -500 {
lab=VDD}
N -490 -540 -300 -540 {
lab=VDD}
N -300 -540 -300 -500 {
lab=VDD}
N -860 -540 -490 -540 {
lab=VDD}
N -510 -470 -490 -470 {
lab=VDD}
N -510 -540 -510 -470 {
lab=VDD}
N -300 -470 -280 -470 {
lab=VDD}
N -280 -540 -280 -470 {
lab=VDD}
N -300 -540 -280 -540 {
lab=VDD}
N -490 -240 -300 -240 {
lab=VSS}
N -370 -240 -370 -60 {
lab=VSS}
N -390 -60 -370 -60 {
lab=VSS}
N -390 -150 -370 -150 {
lab=VSS}
N -300 -340 -230 -340 {
lab=VSS}
N -230 -340 -230 -60 {
lab=VSS}
N -370 -60 -230 -60 {
lab=VSS}
N -560 -340 -490 -340 {
lab=VSS}
N -560 -340 -560 -60 {
lab=VSS}
N -600 -240 -530 -240 {
lab=VPIN}
N -180 -540 -180 -520 {
lab=VDD}
N -60 -540 -60 -520 {
lab=VDD}
N -80 -490 -60 -490 {
lab=VDD}
N -80 -540 -80 -490 {
lab=VDD}
N -200 -490 -180 -490 {
lab=VDD}
N -200 -540 -200 -490 {
lab=VDD}
N -280 -540 -60 -540 {
lab=VDD}
N -610 -540 -610 -520 {
lab=VDD}
N -730 -540 -730 -520 {
lab=VDD}
N -730 -490 -710 -490 {
lab=VDD}
N -710 -540 -710 -490 {
lab=VDD}
N -610 -490 -590 -490 {
lab=VDD}
N -590 -540 -590 -490 {
lab=VDD}
N -140 -490 40 -490 {
lab=VDD}
N -820 -490 -650 -490 {
lab=VDD}
N -820 -580 -820 -490 {
lab=VDD}
N -820 -580 40 -580 {
lab=VDD}
N 40 -580 40 -490 {
lab=VDD}
N -610 -380 -490 -380 {
lab=VPOUT}
N -610 -460 -610 -380 {
lab=VPOUT}
N -300 -380 -180 -380 {
lab=VPOUT}
N -180 -460 -180 -380 {
lab=VPOUT}
N -730 -460 -730 -300 {
lab=#net1}
N -730 -300 -490 -300 {
lab=#net1}
N -300 -300 -60 -300 {
lab=#net2}
N -60 -460 -60 -300 {
lab=#net2}
N -820 -490 -820 -150 {
lab=VDD}
N -820 -150 -430 -150 {
lab=VDD}
N -840 -150 -820 -150 {
lab=VDD}
N -300 -410 -280 -410 {
lab=VPOUT}
N -510 -410 -490 -410 {
lab=VPOUT}
N -180 -240 -180 -200 {
lab=#net4}
N -260 -240 -180 -240 {
lab=#net4}
N -180 -120 -180 -60 {
lab=VSS}
N -230 -60 -180 -60 {
lab=VSS}
N -160 -160 -160 -60 {
lab=VSS}
N -180 -60 -160 -60 {
lab=VSS}
N -160 -280 -160 -160 {
lab=VSS}
N -180 -320 -130 -320 {
lab=VDD}
N -130 -540 -130 -320 {
lab=VDD}
C {CNR_ATR_SKY130NM/CNRATR_NCH_4C1F2.sym} -530 -240 0 0 {name=x2 }
C {CNR_ATR_SKY130NM/CNRATR_NCH_4C1F2.sym} -260 -240 0 1 {name=x3 }
C {devices/ipin.sym} -620 -60 0 0 {name=p1 lab=VSS}
C {devices/ipin.sym} -860 -540 0 0 {name=p2 lab=VDD}
C {CNR_ATR_SKY130NM/CNRATR_NCH_4C1F2.sym} -450 -340 0 1 {name=x1 }
C {CNR_ATR_SKY130NM/CNRATR_NCH_4C1F2.sym} -340 -340 0 0 {name=x4 }
C {CNR_ATR_SKY130NM/CNRATR_NCH_8C1F2.sym} -430 -150 0 0 {name=x7 }
C {CNR_ATR_SKY130NM/CNRATR_PCH_12C1F2.sym} -340 -470 0 0 {name=x5 }
C {CNR_ATR_SKY130NM/CNRATR_PCH_12C1F2.sym} -340 -470 0 0 {name=x6 }
C {CNR_ATR_SKY130NM/CNRATR_PCH_12C1F2.sym} -450 -470 0 1 {name=x8 }
C {CNR_ATR_SKY130NM/CNRATR_PCH_4C1F2.sym} -140 -490 0 1 {name=x9 }
C {CNR_ATR_SKY130NM/CNRATR_PCH_4C1F2.sym} -20 -490 0 1 {name=x10 }
C {CNR_ATR_SKY130NM/CNRATR_PCH_4C1F2.sym} -650 -490 0 0 {name=x11 }
C {CNR_ATR_SKY130NM/CNRATR_PCH_4C1F2.sym} -770 -490 0 0 {name=x12 }
C {devices/ipin.sym} -840 -150 0 0 {name=p3 lab=CLK}
C {devices/ipin.sym} -600 -240 0 0 {name=p5 lab=VPIN}
C {SUN_TR_SKY130NM/SUNTR_RPPO2.sym} -180 -200 3 1 {name=x13 }
C {SUN_TR_SKY130NM/SUNTR_RPPO2.sym} -180 -320 3 1 {name=x14 }
C {devices/opin.sym} -510 -410 0 1 {name=p4 lab=VPOUT}
C {devices/opin.sym} -280 -410 0 0 {name=p6 lab=VNOUT}
