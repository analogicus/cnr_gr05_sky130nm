v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 410 -110 410 -90 {
lab=VSS}
N 260 -110 260 -90 {
lab=VSS}
N 300 -140 300 -90 {
lab=VSS}
N 370 -140 370 -90 {
lab=VSS}
N 260 -260 260 -170 {
lab=VN}
N 260 -310 260 -260 {
lab=VN}
N 300 -420 370 -420 {
lab=#net1}
N 410 -530 410 -450 {
lab=VDD_1V8}
N 260 -530 260 -450 {
lab=VDD_1V8}
N 260 -390 260 -310 {
lab=VN}
N -310 -580 -310 -540 {
lab=VDD_1V8}
N -310 -580 410 -580 {
lab=VDD_1V8}
N 410 -580 410 -530 {
lab=VDD_1V8}
N 260 -580 260 -530 {
lab=VDD_1V8}
N -420 -520 -310 -520 {
lab=VP}
N -420 -500 -310 -500 {
lab=VN}
N -310 -90 410 -90 {
lab=VSS}
N -310 -480 -310 -90 {
lab=VSS}
N -370 -520 -370 -380 {
lab=VP}
N -370 -380 410 -380 {
lab=VP}
N -390 -500 -390 -350 {
lab=VN}
N -390 -350 260 -350 {
lab=VN}
N 410 -390 410 -350 {
lab=VP}
N 230 -420 260 -420 {
lab=VDD_1V8}
N 230 -580 230 -420 {
lab=VDD_1V8}
N 410 -420 440 -420 {
lab=VDD_1V8}
N 440 -580 440 -420 {
lab=VDD_1V8}
N 410 -580 440 -580 {
lab=VDD_1V8}
N 410 -290 410 -270 {
lab=#net2}
N 410 -190 410 -170 {
lab=#net3}
N 410 -270 480 -270 {
lab=#net2}
N 410 -190 480 -190 {
lab=#net3}
N 390 -230 460 -230 {
lab=VSS}
N 340 -230 390 -230 {
lab=VSS}
N 340 -230 340 -90 {
lab=VSS}
N -10 -490 330 -490 {
lab=#net1}
N -10 -540 -10 -490 {
lab=#net1}
N 330 -490 330 -420 {
lab=#net1}
N 330 -490 570 -490 {
lab=#net1}
N 570 -490 570 -420 {
lab=#net1}
N 440 -580 610 -580 {
lab=VDD_1V8}
N 610 -420 640 -420 {
lab=VDD_1V8}
N 640 -580 640 -420 {
lab=VDD_1V8}
N 610 -580 640 -580 {
lab=VDD_1V8}
N 410 -90 610 -90 {
lab=VSS}
N 610 -390 610 -280 {
lab=Vout}
N 610 -310 740 -310 {
lab=Vout}
N 740 -310 740 -280 {
lab=Vout}
N 740 -220 740 -90 {
lab=VSS}
N 610 -90 740 -90 {
lab=VSS}
N 710 -250 740 -250 {
lab=VSS}
N 710 -250 710 -90 {
lab=VSS}
N 610 -220 610 -90 {
lab=VSS}
N 560 -720 560 -630 {
lab=Vout}
N 560 -630 740 -630 {
lab=Vout}
N 740 -630 740 -340 {
lab=Vout}
N 610 -340 740 -340 {
lab=Vout}
N 510 -780 620 -780 {
lab=VDD_1V8}
N 510 -780 510 -580 {
lab=VDD_1V8}
N 630 -780 630 -770 {
lab=VDD_1V8}
N 620 -780 630 -780 {
lab=VDD_1V8}
N 630 -710 630 -680 {
lab=VSS}
N 560 -750 560 -720 {
lab=Vout}
N 560 -750 630 -750 {
lab=Vout}
N 590 -730 630 -730 {
lab=Vthreshold}
N 340 -730 590 -730 {
lab=Vthreshold}
N 630 -680 920 -680 {
lab=VSS}
N 920 -680 920 -100 {
lab=VSS}
N 920 -100 920 -90 {
lab=VSS}
N 740 -90 920 -90 {
lab=VSS}
N 610 -490 610 -450 {
lab=#net4}
N 610 -580 610 -550 {
lab=VDD_1V8}
N 1450 -790 1580 -790 {
lab=Vcomp}
N 780 -250 820 -250 {
lab=TEST1}
N 1560 -770 1580 -770 {
lab=VSS}
N 1560 -810 1580 -810 {
lab=VDD_1V8}
N 1560 -650 1580 -650 {
lab=VSS}
N 1560 -690 1580 -690 {
lab=VDD_1V8}
N 1880 -760 1960 -760 {
lab=TEST2}
N 1880 -810 1880 -760 {
lab=TEST2}
N 1880 -720 1960 -720 {
lab=TEST3}
N 1880 -720 1880 -690 {
lab=TEST3}
N 1920 -720 1920 -700 {
lab=TEST3}
N 1920 -780 1920 -760 {
lab=TEST2}
N 1960 -750 2050 -750 {
lab=TEST2}
N 1960 -760 1960 -750 {
lab=TEST2}
N 1960 -730 1960 -720 {
lab=TEST3}
N 2030 -800 2050 -800 {
lab=VDD_1V8}
N 2050 -800 2050 -770 {
lab=VDD_1V8}
N 2040 -650 2050 -650 {
lab=VSS}
N 2050 -710 2050 -650 {
lab=VSS}
N 2350 -770 2410 -770 {
lab=TEST1}
N 1560 -670 1580 -670 {
lab=VPWR_UP}
N 930 -770 1150 -770 {
lab=Vcomp}
N 2410 -770 2410 -310 {
lab=TEST1}
N 810 -250 2410 -310 {
lab=TEST1}
N 1150 -770 1450 -790 {
lab=Vcomp}
N 1960 -730 2050 -730 {
lab=TEST3}
C {cborder/border_s.sym} 520 0 0 0 {
user="aam"
company="wulff"}
C {devices/ipin.sym} -420 -520 0 0 {name=p4 lab=VP}
C {devices/ipin.sym} -420 -500 0 0 {name=p3 lab=VN}
C {devices/ipin.sym} -310 -480 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} -310 -540 0 0 {name=p1 lab=VDD_1V8}
C {sky130_fd_pr/pnp_05v5.sym} 390 -140 0 0 {name=Q1
model=pnp_05v5_W3p40L3p40
m=2
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 280 -140 0 1 {name=Q2
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {devices/vsource.sym} 410 -320 0 0 {name=Vtest3 value=0 savecurrent=false}
C {SUN_TR_SKY130NM/SUNTR_RPPO2.sym} 410 -270 1 0 {name=x2 }
C {SUN_TR_SKY130NM/SUNTR_RPPO2.sym} 480 -270 1 0 {name=x3 }
C {CNR_GR05_SKY130NM/OTA.sym} -160 -510 0 0 {name=x1}
C {sky130_fd_pr/cap_mim_m3_2.sym} 610 -250 0 0 {name=C3 model=cap_mim_m3_2 W=100 L=200 MF=2 spiceprefix=X}
C {devices/lab_pin.sym} 610 -350 0 1 {name=p5 sig_type=std_logic lab=Vout}
C {devices/ipin.sym} 1560 -670 0 0 {name=p6 lab=VPWR_UP}
C {CNR_GR05_SKY130NM/OTA.sym} 780 -740 0 0 {name=x5}
C {devices/ipin.sym} 340 -730 0 0 {name=p7 lab=Vthreshold}
C {devices/lab_pin.sym} 930 -770 0 1 {name=p8 sig_type=std_logic lab=Vcomp}
C {devices/vsource.sym} 610 -520 0 0 {name=Vtest1 value=0 savecurrent=false}
C {CNR_GR05_SKY130NM/POSEDGE.sym} 1730 -790 0 0 {name=x9}
C {devices/lab_pin.sym} 1560 -810 0 0 {name=p9 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_pin.sym} 1560 -770 0 0 {name=p10 sig_type=std_logic lab=VSS}
C {CNR_GR05_SKY130NM/POSEDGE.sym} 1730 -670 0 0 {name=x10}
C {devices/lab_pin.sym} 1560 -690 0 0 {name=p11 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_pin.sym} 1560 -650 0 0 {name=p12 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1920 -700 0 1 {name=p16 sig_type=std_logic lab=TEST3}
C {devices/lab_pin.sym} 1920 -780 0 1 {name=p17 sig_type=std_logic lab=TEST2}
C {CNR_GR05_SKY130NM/OR.sym} 2200 -740 0 0 {name=x11}
C {devices/lab_pin.sym} 2040 -650 0 0 {name=p13 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2030 -800 0 0 {name=p14 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_pin.sym} 2410 -770 0 1 {name=p15 sig_type=std_logic lab=TEST1}
C {CNR_ATR_SKY130NM/CNRATR_PCH_2C1F2.sym} 570 -420 0 0 {name=x12 }
C {CNR_ATR_SKY130NM/CNRATR_PCH_12C1F2.sym} 370 -420 0 0 {name=x4 }
C {CNR_ATR_SKY130NM/CNRATR_PCH_12C1F2.sym} 300 -420 0 1 {name=x6 }
C {SUN_TR_SKY130NM/SUNTR_RPPO2.sym} 420 -270 1 0 {name=x8 }
C {SUN_TR_SKY130NM/SUNTR_RPPO2.sym} 430 -270 1 0 {name=x13 }
C {CNR_ATR_SKY130NM/CNRATR_NCH_12C1F2.sym} 780 -250 0 1 {name=x14 }
